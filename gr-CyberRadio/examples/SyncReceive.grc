<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ddcGroupEnable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>label</key><value>DDC Group Enable</value></param>
<param><key>labels</key><value>["OFF", "ON"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[False,True]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_update_interval</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>value</key><value>crd.getRadioObject("ndr308", verbose=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioParam</value></param>
<param><key>value</key><value>{"type":"ndr308", "host":"ndr308", "port":8617, "obj":radioObj}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_freq_mhz</value></param>
<param><key>value</key><value>900</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>51.2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_len</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34567</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34568</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34573</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_0_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34569</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_0_0_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34572</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_0_0_0_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34574</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_1</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34571</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0_1_0</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>40001</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_1</value></param>
<param><key>bytes_per_packet</key><value>4136</value></param>
<param><key>header_byte_offset</key><value>36</value></param>
<param><key>port</key><value>34570</value></param>
<param><key>samples_per_packet</key><value>1024</value></param>
<param><key>src_ip</key><value>172.16.2.1</value></param>
<param><key>swap_bytes</key><value>False</value></param>
<param><key>tag_packets</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>a0</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>9</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>40001</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>True</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>1.2e6</value></param>
<param><key>fc</key><value>900e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>label7</key><value></value></param>
<param><key>label8</key><value></value></param>
<param><key>name</key><value>"Freq Domain Pulse"</value></param>
<param><key>nconnections</key><value>8</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>gui_update_interval</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>name</key><value>"Wideband"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>gui_update_interval</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value></value></param>
<param><key>name</key><value>"Time Domain Pulse"</value></param>
<param><key>nconnections</key><value>8</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>gui_update_interval</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Narrowband</value></param>
<param><key>label1</key><value>Wideband</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x1</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>1</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x2</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x3</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>3</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x4</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>4</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x5</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>5</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x6</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>6</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x7</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>7</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>x8</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rf_freq_mhz</value></param>
<param><key>index</key><value>8</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_group_control_block</key>
<param><key>id</key><value>y1</value></param>
<param><key>ddcList</key><value>[1,2,3,4,5,6,7,8]</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>ddcGroupEnable</value></param>
<param><key>index</key><value>1</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z1_0</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>8</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>8</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34574</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z2_0</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>7</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>7</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34573</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z3</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>6</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>6</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34572</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z4</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>5</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>5</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34571</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z5</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>4</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>4</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34570</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z6</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>3</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34569</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z7</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>2</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>2</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34568</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z8</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>dipIndex</key><value>1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>34567</value></param>
<param><key>idString</key><value>"USER"</value></param>
<param><key>localInterface</key><value>eth2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>1</value></param>
<param><key>radioInterface</key><value>1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<connection><source_block_id>CyberRadio_vita_udp_rx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
</flow_graph>
