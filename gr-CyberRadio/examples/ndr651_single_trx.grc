<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr651_single_trx</value></param>
<param><key>author</key><value>NH</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>NDR651 Single Tx/Rx Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>confPath</value></param>
<param><key>value</key><value>os.path.expanduser("~/.ndr651_single_trx.cfg")</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwAmp</value></param>
<param><key>value</key><value>cwAmpCfg</value></param>
<param><key>label</key><value>GR CW Amp (dB)</value></param>
<param><key>min_len</key><value>101</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-90</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>+10</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwAmpCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>-1.0</value></param>
<param><key>option</key><value>amp1</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwAmp</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwFreq</value></param>
<param><key>value</key><value>cwFreqCfg</value></param>
<param><key>label</key><value>GR CW Freq (% BW)</value></param>
<param><key>min_len</key><value>int((80.0/2.5)+1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40.0</value></param>
<param><key>step</key><value>1.25</value></param>
<param><key>stop</key><value>+40.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwFreqCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1.25</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwFreq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ducAtten</value></param>
<param><key>value</key><value>ducAttenCfg</value></param>
<param><key>label</key><value>DUC Attenuation</value></param>
<param><key>min_len</key><value>int(60/0.25)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ducAttenCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>duc</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>ducAtten</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ducFreq</value></param>
<param><key>value</key><value>ducFreqCfg</value></param>
<param><key>label</key><value>DUC Freq (MHz)</value></param>
<param><key>min_len</key><value>4001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-25.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>+25.5</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ducFreqCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>fre</value></param>
<param><key>section</key><value>duc</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>ducFreq</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ducRateIndex</value></param>
<param><key>value</key><value>ducRateIndexCfg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>DUC Rate</value></param>
<param><key>labels</key><value>["%d: %ssps"%(i,num_to_str(ducRateSet[i])) for i in sorted(ducRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(ducRateSet.keys())</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ducRateIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>duc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>ducRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ducRateSet</value></param>
<param><key>value</key><value>radioObj.getWbducRateSet()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>value</key><value>crd.getRadioObject("ndr651", verbose=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioParam</value></param>
<param><key>value</key><value>{"type":"ndr651", "host":hostname, "port":8617, "obj":radioObj}</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txAtten</value></param>
<param><key>value</key><value>txAttenCfg</value></param>
<param><key>label</key><value>TX Atten</value></param>
<param><key>min_len</key><value>16</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txAttenCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>txAtten</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txFreq</value></param>
<param><key>value</key><value>txFreqCfg</value></param>
<param><key>label</key><value>TX Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2</value></param>
<param><key>step</key><value>40</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txFreqCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>txFreq</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>10.0**(float(cwAmp)/20)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>10.0**(float(cwAmp)/20)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>10.0**(float(cwAmp)/20)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>float(cwFreq)/100</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>float(cwFreq)*numpy.pi/50</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>phase_inc</key><value>float(cwFreq)*numpy.pi/50</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataPort</value></param>
<param><key>label</key><value>Radio Data Port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ducIndex</value></param>
<param><key>label</key><value>DUC Index</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ducRateIndex</value></param>
<param><key>label</key><value>DUC Rate Index</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hostname</value></param>
<param><key>label</key><value>Radio Hostname/IP</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr651</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd_0</value></param>
<param><key>import</key><value>import os, numpy, time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_gr_eng_notation</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import *</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>localInterface</value></param>
<param><key>label</key><value>10GbE Port</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"eth6"</value></param>
</block>
<block>
<key>CyberRadio_ndr651_sink</key>
<param><key>id</key><value>new_651_sink</value></param>
<param><key>configTx</key><value>True</value></param>
<param><key>ducAttenuation</key><value>ducAtten</value></param>
<param><key>ducFrequency</key><value>ducFreq*1e6</value></param>
<param><key>ducIndex</key><value>ducIndex</value></param>
<param><key>ducRateIndex</key><value>ducRateIndex</value></param>
<param><key>ducTxChannel</key><value>txChannel</value></param>
<param><key>txInversion</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>hostname</key><value>hostname</value></param>
<param><key>interfaceName</key><value>localInterface</value></param>
<param><key>txAttenuation</key><value>txAtten</value></param>
<param><key>txFrequency</key><value>txFreq</value></param>
<param><key>dataPort</key><value>dataPort</value></param>
<param><key>udpPort</key><value>65000+ducIndex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>CyberRadio_NDR651_duc_sink_mk2</key>
<param><key>id</key><value>old_651_sink</value></param>
<param><key>config_tx</key><value>True</value></param>
<param><key>duc_attenuation</key><value>ducAtten</value></param>
<param><key>duc_channel</key><value>((ducIndex)%8)+1</value></param>
<param><key>duc_frequency</key><value>int( ducFreq*1e6 )</value></param>
<param><key>duc_iface_string</key><value>localInterface</value></param>
<param><key>duc_rate_index</key><value>ducRateIndex</value></param>
<param><key>duc_stream_id</key><value>65000+ducIndex+1</value></param>
<param><key>duc_tx_attenuation</key><value>txAtten</value></param>
<param><key>duc_tx_channels</key><value>1 if txChannel==2 else 2</value></param>
<param><key>duc_tx_frequency</key><value>txFreq+1</value></param>
<param><key>duchsPeThresh</key><value>24</value></param>
<param><key>duchsPfThresh</key><value>25</value></param>
<param><key>duchsPeriod</key><value>10</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>iq_scale_factor</key><value>2**15-1</value></param>
<param><key>tengig_iface_index</key><value>dataPort</value></param>
<param><key>radio_host_name</key><value>hostname</value></param>
<param><key>radio_tcp_port</key><value>8617</value></param>
<param><key>txinvMode</key><value>0</value></param>
<param><key>updatePE</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txChannel</value></param>
<param><key>label</key><value>TX Channel</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_rotator_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0_0</source_block_id><sink_block_id>old_651_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>new_651_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
