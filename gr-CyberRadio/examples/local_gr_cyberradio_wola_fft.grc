<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>local_gr_cyberradio_wola_fft</value></param>
<param><key>category</key><value>[CyberRadio]/Local/DSP</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>[CyberRadio] WOLA FFT (Local)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>int(n_overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avgAlpha</value></param>
<param><key>value</key><value>float(avg_alpha)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftSize</value></param>
<param><key>value</key><value>int(fft_size)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftWindow</value></param>
<param><key>value</key><value>scipy.signal.get_window(windowType, inputSize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftWindowEnergy</value></param>
<param><key>value</key><value>fftWindow.sum()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftWindowScale</value></param>
<param><key>value</key><value>fftWindowEnergy/(fftSize*N)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inputSize</value></param>
<param><key>value</key><value>fftSize*N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>windowType</value></param>
<param><key>value</key><value>str(window_type)</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>adder</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>avg_alpha</value></param>
<param><key>label</key><value>Averaging Alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0**-3.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2**10)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy_signal</value></param>
<param><key>import</key><value>import scipy.signal</value></param>
</block>
<block>
<key>CyberRadio_log_mag_fft</key>
<param><key>id</key><value>logMagFFT_large</value></param>
<param><key>numInputs</key><value>1</value></param>
<param><key>iirAlpha</key><value>avgAlpha</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftSize</key><value>inputSize</value></param>
<param><key>resetOnAlphaChange</key><value>False</value></param>
<param><key>secondaryOutput</key><value>mag</value></param>
<param><key>windowType</key><value>windowType</value></param>
</block>
<block>
<key>CyberRadio_log_mag_fft</key>
<param><key>id</key><value>logMagFFT_small</value></param>
<param><key>numInputs</key><value>1</value></param>
<param><key>iirAlpha</key><value>avgAlpha</value></param>
<param><key>fftSize</key><value>fftSize</value></param>
<param><key>resetOnAlphaChange</key><value>False</value></param>
<param><key>secondaryOutput</key><value>mag</value></param>
<param><key>windowType</key><value>windowType</value></param>
</block>
<block>
<key>CyberRadio_log_mag_fft</key>
<param><key>id</key><value>logMagFFT_wola</value></param>
<param><key>numInputs</key><value>1</value></param>
<param><key>iirAlpha</key><value>avgAlpha</value></param>
<param><key>fftSize</key><value>fftSize</value></param>
<param><key>resetOnAlphaChange</key><value>False</value></param>
<param><key>secondaryOutput</key><value>mag</value></param>
<param><key>windowType</key><value>"boxcar"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiplyConstant_0</value></param>
<param><key>const</key><value>fftWindow[0*fftSize:(0+1)*fftSize]/fftWindowScale</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiplyConstant_1</value></param>
<param><key>const</key><value>fftWindow[1*fftSize:(1+1)*fftSize]/fftWindowScale</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiplyConstant_2</value></param>
<param><key>const</key><value>fftWindow[2*fftSize:(2+1)*fftSize]/fftWindowScale</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>multiplyConstant_3</value></param>
<param><key>const</key><value>fftWindow[3*fftSize:(3+1)*fftSize]/fftWindowScale</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_overlap</value></param>
<param><key>label</key><value>Overlap</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink_large</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>inputSize</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink_small</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink_wola</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>wola_fft</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>small_fft</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>big_fft</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>fft_size*n_overlap</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>src_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size*n_overlap</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>src_1</value></param>
<param><key>label</key><value>reset</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
<param><key>vlen</key><value>fftSize*N</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>vecToStreams</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>window_type</value></param>
<param><key>label</key><value>Window Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"blackmanharris"</value></param>
</block>
<connection><source_block_id>adder</source_block_id><sink_block_id>logMagFFT_wola</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_large</source_block_id><sink_block_id>nullSink_large</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_large</source_block_id><sink_block_id>sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_large</source_block_id><sink_block_id>nullSink_large</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>logMagFFT_small</source_block_id><sink_block_id>nullSink_small</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_small</source_block_id><sink_block_id>sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_small</source_block_id><sink_block_id>nullSink_small</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>logMagFFT_small</source_block_id><sink_block_id>sink_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>logMagFFT_wola</source_block_id><sink_block_id>nullSink_wola</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_wola</source_block_id><sink_block_id>sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logMagFFT_wola</source_block_id><sink_block_id>nullSink_wola</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>logMagFFT_wola</source_block_id><sink_block_id>sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>multiplyConstant_0</source_block_id><sink_block_id>adder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiplyConstant_1</source_block_id><sink_block_id>adder</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>multiplyConstant_2</source_block_id><sink_block_id>adder</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>multiplyConstant_3</source_block_id><sink_block_id>adder</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>src_0</source_block_id><sink_block_id>logMagFFT_large</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_0</source_block_id><sink_block_id>vecToStreams</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_1</source_block_id><sink_block_id>logMagFFT_large</sink_block_id><source_key>out</source_key><sink_key>reset</sink_key></connection>
<connection><source_block_id>src_1</source_block_id><sink_block_id>logMagFFT_small</sink_block_id><source_key>out</source_key><sink_key>reset</sink_key></connection>
<connection><source_block_id>src_1</source_block_id><sink_block_id>logMagFFT_wola</sink_block_id><source_key>out</source_key><sink_key>reset</sink_key></connection>
<connection><source_block_id>vecToStreams</source_block_id><sink_block_id>logMagFFT_small</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStreams</source_block_id><sink_block_id>multiplyConstant_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStreams</source_block_id><sink_block_id>multiplyConstant_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStreams</source_block_id><sink_block_id>multiplyConstant_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStreams</source_block_id><sink_block_id>multiplyConstant_3</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
