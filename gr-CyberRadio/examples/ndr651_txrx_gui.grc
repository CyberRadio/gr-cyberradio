<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr651_txrx_gui</value></param>
<param><key>category</key><value>Local</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>NDR651 High-Res FFT</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>autoNbddcFreq</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>controlTabs@0:5,0,1,1</value></param>
<param><key>label</key><value>Auto NBDDC Freq?</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>confPath</value></param>
<param><key>value</key><value>os.path.expanduser( "~/ndr651_txrx_gui.conf" )</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwAmp1</value></param>
<param><key>value</key><value>cwAmp1Cfg</value></param>
<param><key>gui_hint</key><value>controlTabs@2:1,0,1,1</value></param>
<param><key>label</key><value>GR CW Amp 1 (dB)</value></param>
<param><key>min_len</key><value>101</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-90</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>+10</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwAmp1Cfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>-1.0</value></param>
<param><key>option</key><value>amp1</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwAmp1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwAmp2</value></param>
<param><key>value</key><value>cwAmp2Cfg</value></param>
<param><key>gui_hint</key><value>controlTabs@2:3,0,1,1</value></param>
<param><key>label</key><value>GR CW Amp 2 (dB)</value></param>
<param><key>min_len</key><value>101</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-90.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>+10.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwAmp2Cfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>-1.0</value></param>
<param><key>option</key><value>amp2</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwAmp2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwFreq1</value></param>
<param><key>value</key><value>cwFreq1Cfg</value></param>
<param><key>gui_hint</key><value>controlTabs@2:0,0,1,1</value></param>
<param><key>label</key><value>GR CW Freq 1 (% BW)</value></param>
<param><key>min_len</key><value>int((80.0/2.5)+1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40.0</value></param>
<param><key>step</key><value>1.25</value></param>
<param><key>stop</key><value>+40.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwFreq1Cfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1.25</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwFreq1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cwFreq2</value></param>
<param><key>value</key><value>cwFreq2Cfg</value></param>
<param><key>gui_hint</key><value>controlTabs@2:2,0,1,1</value></param>
<param><key>label</key><value>GR CW Freq 2 (% BW)</value></param>
<param><key>min_len</key><value>int((80.0/2.5)+1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40.0</value></param>
<param><key>step</key><value>1.25</value></param>
<param><key>stop</key><value>+40.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cwFreq2Cfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>-1.25</value></param>
<param><key>option</key><value>freq2</value></param>
<param><key>section</key><value>cw</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>cwFreq2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ducAtten</value></param>
<param><key>value</key><value>ducAttenCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:4,0,1,1</value></param>
<param><key>label</key><value>DUC Attenuation</value></param>
<param><key>min_len</key><value>int(60/0.25)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ducAttenCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>duc</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>ducAtten</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ducFreq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controlTabs@0:3,0,1,2</value></param>
<param><key>label</key><value>DUC Freq (MHz)</value></param>
<param><key>min_len</key><value>4001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-25.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>+25.5</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ducIndexLabel</value></param>
<param><key>value</key><value>ducIndex</value></param>
<param><key>gui_hint</key><value>controlTabs@0:2,0,1,1</value></param>
<param><key>label</key><value>DUC Index</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ducRateIndex</value></param>
<param><key>value</key><value>ducRateIndexCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:2,1,1,1</value></param>
<param><key>label</key><value>DUC Rate</value></param>
<param><key>labels</key><value>["%d: %ssps"%(i,num_to_str(ducRateSet[i])) for i in sorted(ducRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(ducRateSet.keys())</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ducRateIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>duc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>ducRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ducRateSet</value></param>
<param><key>value</key><value>radioObj.getWbducRateSet()</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ducTxinvMode</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>controlTabs@0:4,1,1,1</value></param>
<param><key>label</key><value>DUC Tx Spectral Inversion</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>duchsPeThresh</value></param>
<param><key>value</key><value>duchsPfThresh-1</value></param>
<param><key>gui_hint</key><value>controlTabs@1:1,1,1,1</value></param>
<param><key>label</key><value>DUCHS PE Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>duchsPeriodHz</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>controlTabs@1:0,1,1,1</value></param>
<param><key>label</key><value>DDC Period (Hz)</value></param>
<param><key>labels</key><value>["%0.1fHz, Period=%d*5ms"%(i, 1.0/float(i)/5e-3) for i in duchsPeriodList]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>duchsPeriodList</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>duchsPeriodList</value></param>
<param><key>value</key><value>[0.2,0.5,1,2,5,10,20,50,100,200]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>duchsPfThresh</value></param>
<param><key>value</key><value>25</value></param>
<param><key>gui_hint</key><value>controlTabs@1:1,0,1,1</value></param>
<param><key>label</key><value>DUCHS PF Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iface1</value></param>
<param><key>value</key><value>localInterface2 if dataPort1==2 else localInterface1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iface2</value></param>
<param><key>value</key><value>localInterface2 if dataPort2==2 else localInterface1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcFreq</value></param>
<param><key>value</key><value>nbddcFreq_autoCalc if ( autoNbddcFreq and (numpy.abs(nbddcFreq_autoCalc)&lt;=25.6e6) )else nbddcFreqSlider*1e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>nbddcFreqLabel</value></param>
<param><key>value</key><value>num_to_str(nbddcFreq)+"Hz"</value></param>
<param><key>gui_hint</key><value>controlTabs@0:5,1,1,1</value></param>
<param><key>label</key><value>Applied</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcFreqSlider</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controlTabs@0:6,0,1,2</value></param>
<param><key>label</key><value>Manual (MHz)</value></param>
<param><key>min_len</key><value>int((40/0.1)+1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>+20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcFreq_autoCalc</value></param>
<param><key>value</key><value>numpy.round( (ducFreq-rxFreqOffset)*1e6+(((-1)**(2-ducTxinvMode))*cwFreq1/100.0*ducRateSet[ducRateIndex]) - nbddcRateSet[nbddcRateIndex]/16 )</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcIndex</value></param>
<param><key>value</key><value>nbddcIndexCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,0,1,1</value></param>
<param><key>label</key><value>NBDDC</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radioObj.getNbddcIndexRange()</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>nbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcIndex</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcRateIndex</value></param>
<param><key>value</key><value>nbddcRateIndexCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,1,1,1</value></param>
<param><key>label</key><value>NBDDC Rate</value></param>
<param><key>labels</key><value>["Disabled",]+["%d: %ssps"%(i,num_to_str(nbddcRateSet[i])) for i in sorted(nbddcRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1]+sorted(nbddcRateSet.keys())</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcRateIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>nbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcRateSet</value></param>
<param><key>value</key><value>radioObj.getNbddcRateSet()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>value</key><value>crd.getRadioObject("ndr651", verbose=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioParam</value></param>
<param><key>value</key><value>{"type":"ndr651", "host":hostname, "port":8617, "obj":radioObj}</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxAtten</value></param>
<param><key>value</key><value>rxAttenCfg</value></param>
<param><key>gui_hint</key><value>topTabs@0:1,3,1,1</value></param>
<param><key>label</key><value>RX Atten</value></param>
<param><key>min_len</key><value>31</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxAttenCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rxAtten</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxFreq</value></param>
<param><key>value</key><value>(txFreq+rxFreqOffset) if ((txFreq+rxFreqOffset)&gt;=20) else 20</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxFreqCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>option</key><value>freq_offset</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rxFreqOffset</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxFreqOffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>topTabs@0:1,1,1,1</value></param>
<param><key>label</key><value>RX Offset (MHz)</value></param>
<param><key>min_len</key><value>int((1000/10)+1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-500</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>+500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txAtten</value></param>
<param><key>value</key><value>txAttenCfg</value></param>
<param><key>gui_hint</key><value>topTabs@0:1,2,1,1</value></param>
<param><key>label</key><value>TX Atten</value></param>
<param><key>min_len</key><value>16</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txAttenCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>txAtten</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txFreq</value></param>
<param><key>value</key><value>txFreqCfg</value></param>
<param><key>gui_hint</key><value>topTabs@0:1,0,1,1</value></param>
<param><key>label</key><value>TX Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2</value></param>
<param><key>step</key><value>40</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txFreqCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>tx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>txFreq</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>txsumChoice</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controlTabs@2</value></param>
<param><key>label</key><value>Tx Output Sum</value></param>
<param><key>labels</key><value>["0:  1 / 2 / -","1: 1+E/ 2 / -","2: 1 / 2+E / -","3: - /1+2/ -","4: - / 1+2+E / -","5: - / 2 / 1","6: - / 2 /1+E","7: 1 / - / 2","8: 1 / - /2+E","9:  - / - /ALL","10: 1 / 2 / E"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>range(11)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udpPort</value></param>
<param><key>value</key><value>33222</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>updatePE</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>controlTabs@1:0,0,1,1</value></param>
<param><key>label</key><value>Flow Control Update</value></param>
<param><key>labels</key><value>["Periodic", "Empty Flag"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[False, True]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcIndex</value></param>
<param><key>value</key><value>wbddcIndexCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,0,1,1</value></param>
<param><key>label</key><value>NB Tuner Source</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radioObj.getWbddcIndexRange()</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbddcIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>wbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcIndex</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcRateIndex</value></param>
<param><key>value</key><value>wbddcRateIndexCfg</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,1,1,1</value></param>
<param><key>label</key><value>WBDDC Rate</value></param>
<param><key>labels</key><value>["Disabled",]+["%d: %ssps"%(i,num_to_str(wbddcRateSet[i])) for i in sorted(wbddcRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1]+sorted(wbddcRateSet.keys())</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbddcRateIndexCfg</value></param>
<param><key>config_file</key><value>confPath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>wbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcRateSet</value></param>
<param><key>value</key><value>radioObj.getWbddcRateSet()</value></param>
</block>
<block>
<key>CyberRadio_NDR651_duc_sink_mk2</key>
<param><key>id</key><value>AAA_CyberRadio_NDR651_duc_sink_mk2_0</value></param>
<param><key>config_tx</key><value>True</value></param>
<param><key>duc_attenuation</key><value>ducAtten</value></param>
<param><key>duc_channel</key><value>((ducIndex-1)%8)+1</value></param>
<param><key>duc_frequency</key><value>int( ducFreq*1e6 )</value></param>
<param><key>duc_iface_string</key><value>iface1</value></param>
<param><key>duc_rate_index</key><value>ducRateIndex</value></param>
<param><key>duc_stream_id</key><value>57005</value></param>
<param><key>duc_tx_attenuation</key><value>txAtten</value></param>
<param><key>duc_tx_channels</key><value>1</value></param>
<param><key>duc_tx_frequency</key><value>txFreq</value></param>
<param><key>duchsPeThresh</key><value>24</value></param>
<param><key>duchsPfThresh</key><value>25</value></param>
<param><key>duchsPeriod</key><value>10</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>iq_scale_factor</key><value>2**15-1</value></param>
<param><key>tengig_iface_index</key><value>dataPort1</value></param>
<param><key>radio_host_name</key><value>hostname</value></param>
<param><key>radio_tcp_port</key><value>8617</value></param>
<param><key>txinvMode</key><value>ducTxinvMode</value></param>
<param><key>updatePE</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_NDR651_duc_sink_mk2</key>
<param><key>id</key><value>AAA_CyberRadio_NDR651_duc_sink_mk2_1</value></param>
<param><key>config_tx</key><value>True</value></param>
<param><key>duc_attenuation</key><value>ducAtten</value></param>
<param><key>duc_channel</key><value>(ducIndex%8)+1</value></param>
<param><key>duc_frequency</key><value>int( ducFreq*1e6 )</value></param>
<param><key>duc_iface_string</key><value>iface2</value></param>
<param><key>duc_rate_index</key><value>ducRateIndex</value></param>
<param><key>duc_stream_id</key><value>57005+1</value></param>
<param><key>duc_tx_attenuation</key><value>txAtten</value></param>
<param><key>duc_tx_channels</key><value>2</value></param>
<param><key>duc_tx_frequency</key><value>txFreq</value></param>
<param><key>duchsPeThresh</key><value>24</value></param>
<param><key>duchsPfThresh</key><value>25</value></param>
<param><key>duchsPeriod</key><value>10</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>iq_scale_factor</key><value>2**15-1</value></param>
<param><key>tengig_iface_index</key><value>dataPort2</value></param>
<param><key>radio_host_name</key><value>hostname</value></param>
<param><key>radio_tcp_port</key><value>8617</value></param>
<param><key>txinvMode</key><value>ducTxinvMode</value></param>
<param><key>updatePE</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_generic_ndr_command_block</key>
<param><key>id</key><value>aaaa_command_block</value></param>
<param><key>cmd</key><value>"TXSUM %d"%(txsumChoice)</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>10.0**(float(cwAmp1)/20)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>10.0**(float(cwAmp2)/20)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>float(cwFreq1)*numpy.pi/50</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0_0</value></param>
<param><key>phase_inc</key><value>float(cwFreq2)*numpy.pi/50</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controlTabs</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>DDC/DUC Settings</value></param>
<param><key>label1</key><value>Flow Control</value></param>
<param><key>label2</key><value>Sig Gen and TXSUM</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataPort1</value></param>
<param><key>label</key><value>Radio Data Port for DUC/DDC 1</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataPort2</value></param>
<param><key>label</key><value>Radio Data Port for DUC/DDC 2</value></param>
<param><key>short_id</key><value>P</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dipIndex</value></param>
<param><key>label</key><value>DIP Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ducIndex</value></param>
<param><key>label</key><value>DUC Index</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftRate</value></param>
<param><key>label</key><value>FFT Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftSizeExp</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hostname</value></param>
<param><key>label</key><value>Radio Hostname/IP</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr651</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iirAvgGain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>IIR Avg. Gain Exponent (2^-x)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd_0</value></param>
<param><key>import</key><value>import os, numpy, time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_gr_eng_notation</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import *</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>localInterface</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>10GbE Port #1</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"eth6"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>localInterface1</value></param>
<param><key>label</key><value>10GbE Port #1</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"eth0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>localInterface2</value></param>
<param><key>label</key><value>10GbE Port #2</value></param>
<param><key>short_id</key><value>I</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"eth7"</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>(9+1024+1)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>(9+1024+1)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>nullSink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>(9+1024+1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>otherDdcArgs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Other DDC Args</value></param>
<param><key>value</key><value>{}</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>otherTunerArgs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Other Tuner Args</value></param>
<param><key>value</key><value>{}</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>plotTabs</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label0</key><value>Narrowband Rx</value></param>
<param><key>label1</key><value>Tx Signal</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>nbddcRateSet[nbddcRateIndex]</value></param>
<param><key>fc</key><value>((txFreq+rxFreqOffset)*1e6)+nbddcFreq</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>gui_hint</key><value>plotTabs@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>name</key><value>NBDDC</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/8</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>wbddcRateSet[wbddcRateIndex]</value></param>
<param><key>fc</key><value>rxFreq*1e6</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>topTabs@0:0,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Rx 1</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>Rx 2</value></param>
<param><key>name</key><value>Wideband Receivers</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/4</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>ducRateSet[ducRateIndex]</value></param>
<param><key>fc</key><value>(txFreq)*1e6</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>gui_hint</key><value>plotTabs@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Tx 1</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>Tx 2</value></param>
<param><key>name</key><value>DUC</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioInterface</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Radio Ethernet Interface Index</value></param>
<param><key>short_id</key><value>I</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>topTabs</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label0</key><value>WBDDC</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>vecToStream_iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>vecToStream_iq_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>vecToStream_iq_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source_2</key>
<param><key>id</key><value>y_vitaIqSource_nb</value></param>
<param><key>byteSwapped</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>iqSwapped</key><value>True</value></param>
<param><key>coherent</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>payloadSize</key><value>1024*4</value></param>
<param><key>port</key><value>udpPort+1</value></param>
<param><key>tagOutput</key><value>False</value></param>
<param><key>vitaHeaderSize</key><value>9*4</value></param>
<param><key>vitaTailSize</key><value>1*4</value></param>
<param><key>vitaType</key><value>3</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source_2</key>
<param><key>id</key><value>y_vitaIqSource_wb</value></param>
<param><key>byteSwapped</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>iqSwapped</key><value>True</value></param>
<param><key>coherent</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>payloadSize</key><value>1024*4</value></param>
<param><key>port</key><value>udpPort</value></param>
<param><key>tagOutput</key><value>False</value></param>
<param><key>vitaHeaderSize</key><value>9*4</value></param>
<param><key>vitaTailSize</key><value>1*4</value></param>
<param><key>vitaType</key><value>3</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source_2</key>
<param><key>id</key><value>y_vitaIqSource_wb_0</value></param>
<param><key>byteSwapped</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>iqSwapped</key><value>True</value></param>
<param><key>coherent</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>payloadSize</key><value>1024*4</value></param>
<param><key>port</key><value>udpPort+2</value></param>
<param><key>tagOutput</key><value>False</value></param>
<param><key>vitaHeaderSize</key><value>9*4</value></param>
<param><key>vitaTailSize</key><value>1*4</value></param>
<param><key>vitaType</key><value>3</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z_ddcControl_nb</value></param>
<param><key>enable</key><value>nbddcRateIndex in nbddcRateSet</value></param>
<param><key>freq</key><value>nbddcFreq</value></param>
<param><key>index</key><value>nbddcIndex</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>nbddcRateIndex if nbddcRateIndex in nbddcRateSet else 0</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>udpPort+1</value></param>
<param><key>localInterface</key><value>""</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>wbddcIndex</value></param>
<param><key>radioInterface</key><value>dataPort1</value></param>
<param><key>wideband</key><value>False</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z_ddcControl_wb</value></param>
<param><key>enable</key><value>wbddcRateIndex in wbddcRateSet</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>wbddcRateIndex if wbddcRateIndex in wbddcRateSet else 0</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>udpPort</value></param>
<param><key>localInterface</key><value>""</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>wbddcIndex</value></param>
<param><key>radioInterface</key><value>dataPort1</value></param>
<param><key>wideband</key><value>True</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>z_ddcControl_wb_0</value></param>
<param><key>enable</key><value>wbddcRateIndex in wbddcRateSet</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>index</key><value>2</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>wbddcRateIndex if wbddcRateIndex in wbddcRateSet else 0</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>udpPort</key><value>udpPort+2</value></param>
<param><key>localInterface</key><value>""</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>wbddcIndex</value></param>
<param><key>radioInterface</key><value>dataPort2</value></param>
<param><key>wideband</key><value>True</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>z_tunerControl</value></param>
<param><key>attenuation</key><value>rxAtten</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rxFreq</value></param>
<param><key>index</key><value>1</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>z_tunerControl_0</value></param>
<param><key>attenuation</key><value>rxAtten</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>rxFreq</value></param>
<param><key>index</key><value>2</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_rotator_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>AAA_CyberRadio_NDR651_duc_sink_mk2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0_0</source_block_id><sink_block_id>AAA_CyberRadio_NDR651_duc_sink_mk2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vecToStream_iq</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStream_iq_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vecToStream_iq_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_nb</source_block_id><sink_block_id>vecToStream_iq</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_nb</source_block_id><sink_block_id>nullSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_wb</source_block_id><sink_block_id>vecToStream_iq_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_wb</source_block_id><sink_block_id>nullSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_wb_0</source_block_id><sink_block_id>vecToStream_iq_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_vitaIqSource_wb_0</source_block_id><sink_block_id>nullSink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
