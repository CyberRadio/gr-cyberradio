<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>frq_strobe_test</value></param>
<param><key>author</key><value>NH</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Freq Msg Strobe Test</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_dynRange</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>120</value></param>
<param><key>option</key><value>dyn_range</value></param>
<param><key>section</key><value>display</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>dynRange</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_iirAvgExp</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(3)</value></param>
<param><key>option</key><value>iirAvgExp</value></param>
<param><key>section</key><value>gui</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>iirAvgExp</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_refLevel</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ref_level</value></param>
<param><key>section</key><value>display</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>refLevel</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_rfFreqMhz</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfFreqMhz</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_tunerAtten</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(radioObj.getTunerAttenuationRange()[0])</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>tunerAtten</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_tunerIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>radioObj.getTunerIndexRange()[0]</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>tunerIndex</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_wbddcRateIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>sorted(wbddcRateSet.keys())[0]</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>wbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>configFilePath</value></param>
<param><key>value</key><value>os.path.expanduser( os.path.join("~",".%s_demo.cfg"%(radioObj.name.lower(),)) )</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dwell</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,4,1,1</value></param>
<param><key>label</key><value>dwell</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10.0</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dynRange</value></param>
<param><key>value</key><value>cfg_dynRange</value></param>
<param><key>gui_hint</key><value>wbTabs@0:1,1,1,1</value></param>
<param><key>label</key><value>"Dyn.\nRange\n(dB)"</value></param>
<param><key>min_len</key><value>(195/5)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f1</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,1,1,1</value></param>
<param><key>label</key><value>f1 (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>int(radioObj.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f2</value></param>
<param><key>value</key><value>int(radioObj.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,2,1,1</value></param>
<param><key>label</key><value>f2 (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>int(radioObj.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fStep</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,3,1,1</value></param>
<param><key>label</key><value>Step (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iirAlpha</value></param>
<param><key>value</key><value>2.0**(float(-iirAvgExp))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>iirAvgExp</value></param>
<param><key>value</key><value>cfg_iirAvgExp</value></param>
<param><key>gui_hint</key><value>wbTabs@0:2,1,1,1</value></param>
<param><key>label</key><value>Avg.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>pauseScan</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>controlTabs@0:1,0,1,1</value></param>
<param><key>label0</key><value>Run</value></param>
<param><key>label1</key><value>Pause</value></param>
<param><key>label</key><value>Scan</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_radio_object</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>radioHostname</key><value>radioHostname</value></param>
<param><key>radioType</key><value>radioType</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>refLevel</value></param>
<param><key>value</key><value>cfg_refLevel</value></param>
<param><key>gui_hint</key><value>wbTabs@0:0,1,1,1</value></param>
<param><key>label</key><value>"Ref.\nLevel\n(dB)"</value></param>
<param><key>min_len</key><value>(130/5)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>+10</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfFreqMhz</value></param>
<param><key>value</key><value>cfg_rfFreqMhz</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,3,1,2</value></param>
<param><key>label</key><value>Tuner Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>int(radioObj.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tunerAtten</value></param>
<param><key>value</key><value>cfg_tunerAtten</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,2,1,1</value></param>
<param><key>label</key><value>Tuner Atten (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerAttenuationRange()[0])</value></param>
<param><key>step</key><value>int(radioObj.getTunerAttenuationRes())</value></param>
<param><key>stop</key><value>int(radioObj.getTunerAttenuationRange()[1])</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>tunerIndex</value></param>
<param><key>value</key><value>cfg_tunerIndex</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,0,1,1</value></param>
<param><key>label</key><value>Tuner Index</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radioObj.getTunerIndexRange()</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udpBasePort</value></param>
<param><key>value</key><value>0xcafe</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbBw</value></param>
<param><key>value</key><value>wbddcBwSet[wbddcRateIndex]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbSampleRate</value></param>
<param><key>value</key><value>wbddcRateSet[wbddcRateIndex]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcBwSet</value></param>
<param><key>value</key><value>dict( [(k,v) for k,v in radioObj.getWbddcBwSet().iteritems() if radioObj.getDdcDataFormat(True).get(k,"iq")!="real"] )</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcRateIndex</value></param>
<param><key>value</key><value>cfg_wbddcRateIndex</value></param>
<param><key>gui_hint</key><value>controlTabs@0:0,1,1,1</value></param>
<param><key>label</key><value>WBDDC Sample Rate</value></param>
<param><key>labels</key><value>["%d: %ssps"%(k,num_to_str(wbddcRateSet[k])) for k in sorted(wbddcRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(wbddcRateSet.keys())</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcRateSet</value></param>
<param><key>value</key><value>dict( [(k,v) for k,v in radioObj.getWbddcRateSet().iteritems() if radioObj.getDdcDataFormat(True).get(k,"iq")!="real"] )</value></param>
</block>
<block>
<key>CyberRadio_freq_msg_strobe</key>
<param><key>id</key><value>CyberRadio_freq_msg_strobe_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>dwell</key><value>dwell</value></param>
<param><key>f1</key><value>f1</value></param>
<param><key>f2</key><value>f2</value></param>
<param><key>fManual</key><value>rfFreqMhz</value></param>
<param><key>msgRes</key><value>1.0e6</value></param>
<param><key>msgUnits</key><value>1.0</value></param>
<param><key>pause</key><value>bool(pauseScan)</value></param>
<param><key>wrap</key><value>True</value></param>
<param><key>step</key><value>fStep</value></param>
</block>
<block>
<key>CyberRadio_generic_group_control_block</key>
<param><key>id</key><value>CyberRadio_generic_group_control_block_0</value></param>
<param><key>ddcList</key><value>[0,1,2,3,]</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>False</value></param>
<param><key>index</key><value>0</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>wideband</key><value>True</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0</value></param>
<param><key>bytes_per_packet</key><value>radioObj.getVitaHeaderSize()+radioObj.getVitaPayloadSize()+radioObj.getVitaTailSize()</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>header_byte_offset</key><value>radioObj.getVitaHeaderSize()</value></param>
<param><key>port</key><value>udpBasePort</value></param>
<param><key>samples_per_packet</key><value>radioObj.getVitaPayloadSize()/4</value></param>
<param><key>src_ip</key><value>0.0.0.0</value></param>
<param><key>swap_bytes</key><value>radioObj.isByteswapped()</value></param>
<param><key>swap_iq</key><value>radioObj.isIqSwapped()</value></param>
<param><key>tag_packets</key><value>False</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_zero_copy_source</key>
<param><key>id</key><value>CyberRadio_zero_copy_source_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>filterString</key><value>"ip proto 17 and ip dst 255.255.255.255 and udp dst port %d"%(udpBasePort,)</value></param>
<param><key>vectorLen</key><value>1</value></param>
<param><key>headerOffset</key><value>radioObj.getVitaHeaderSize()</value></param>
<param><key>destIP</key><value>255.255.255.255</value></param>
<param><key>port</key><value>udpBasePort</value></param>
<param><key>samplesPerFrame</key><value>radioObj.getVitaPayloadSize()/4</value></param>
<param><key>byteSwap</key><value>radioObj.isByteswapped()</value></param>
<param><key>iqSwap</key><value>radioObj.isIqSwapped()</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0.1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10.0**(float(pn_amp)/20)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.7</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(2**pn_ovs)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>radioObj.getVitaPayloadSize()/4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controlTabs</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>digital_glfsr_source_x</key>
<param><key>id</key><value>digital_glfsr_source_x_0</value></param>
<param><key>degree</key><value>pn_degree</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mask</key><value>0</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>seed</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_eng_notation_start</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import *</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pn_amp</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PN Sequency Amplitude</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-3.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pn_degree</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PN Sequence Degree</value></param>
<param><key>short_id</key><value>D</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pn_ovs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PN Sequence Oversampling</value></param>
<param><key>short_id</key><value>O</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pn_samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PN Sample Rate (Msps)</value></param>
<param><key>short_id</key><value>S</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.125</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pn_tx_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PN Sequency TX Gain</value></param>
<param><key>short_id</key><value>G</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>wbSampleRate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>wbTabs@0:0,0,3,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/32</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>refLevel</value></param>
<param><key>ymin</key><value>refLevel-dynRange</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioHostname</value></param>
<param><key>label</key><value>Radio Hostname</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.0.20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioType</value></param>
<param><key>label</key><value>Radio Type</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr364</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>rfFreqMhz*1e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>pn_tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>pn_samp_rate*1e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request_t((rfFreqMhz+1)*1e6, 2*samp_rate)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>otw</key><value>sc8</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>various_imports</value></param>
<param><key>import</key><value>import os, numpy, json, scipy.signal</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>wbTabs</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>y_ddcControl</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>tunerIndex</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>wbddcRateIndex</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>udpPort</key><value>udpBasePort</value></param>
<param><key>localInterface</key><value></value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>phaseOffset</key><value>0.0</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>tunerIndex</value></param>
<param><key>radioInterface</key><value>-1</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>wideband</key><value>True</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>z_tunerControl</value></param>
<param><key>attenuation</key><value>tunerAtten</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>index</key><value>tunerIndex</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>group</key><value>None</value></param>
</block>
<connection><source_block_id>CyberRadio_freq_msg_strobe_0</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>freq</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>CyberRadio_freq_msg_strobe_0</source_block_id><sink_block_id>z_tunerControl</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>y_ddcControl</sink_block_id><source_key>status</source_key><sink_key>udp</sink_key></connection>
<connection><source_block_id>CyberRadio_zero_copy_source_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_glfsr_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>y_ddcControl</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>status</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>y_ddcControl</source_block_id><sink_block_id>CyberRadio_vita_udp_rx_0_0</sink_block_id><source_key>udp</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>z_tunerControl</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
