<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>local_CyberRadio_DDC_Source</value></param>
<param><key>category</key><value>[CyberRadio]/Local</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>[CyberRadio(local)] DDC Source (Control+IQ)</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>ddcControl</value></param>
<param><key>enable</key><value>enable</value></param>
<param><key>freq</key><value>ddcFreq</value></param>
<param><key>index</key><value>ddcIndex</value></param>
<param><key>mode</key><value>ddcModeFormat</value></param>
<param><key>rate</key><value>rateIndex</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>udpPort</key><value>udpPort</value></param>
<param><key>localInterface</key><value></value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>phaseOffset</key><value>ddcPhase</value></param>
<param><key>rfFreq</key><value>int(rfFreq)</value></param>
<param><key>rfSource</key><value>tunerIndex</value></param>
<param><key>radioInterface</key><value>-1</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>wideband</key><value>wideband</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ddcFreq</value></param>
<param><key>label</key><value>DDC Frequency Offset (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ddcIndex</value></param>
<param><key>label</key><value>DDC Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ddcModeFormat</value></param>
<param><key>label</key><value>DDC Mode/Format</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ddcPhase</value></param>
<param><key>label</key><value>DDC Phase Offset (degrees)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable</value></param>
<param><key>label</key><value>Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_0_0</value></param>
<param><key>label</key><value>Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>msg_sink_status_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>status</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>msg_sink_status_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>msg_sink_status_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>freq</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>msg_src_control_0</value></param>
<param><key>label</key><value>control</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>msg_src_control_0_0</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>label</key><value>Radio Object</value></param>
<param><key>value</key><value>crd.getRadioObject("ndr308")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rateIndex</value></param>
<param><key>label</key><value>DDC Rate Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfFreq</value></param>
<param><key>label</key><value>RF Freq (MHz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tunerIndex</value></param>
<param><key>label</key><value>RF Source</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udpPort</value></param>
<param><key>label</key><value>UDP Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>12345</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>udpSource</value></param>
<param><key>bytes_per_packet</key><value>radioObj.getVitaHeaderSize()+radioObj.getVitaPayloadSize()+radioObj.getVitaTailSize()</value></param>
<param><key>header_byte_offset</key><value>radioObj.getVitaHeaderSize()</value></param>
<param><key>port</key><value>udpPort</value></param>
<param><key>samples_per_packet</key><value>radioObj.getVitaPayloadSize()/4</value></param>
<param><key>src_ip</key><value>0.0.0.0</value></param>
<param><key>swap_bytes</key><value>radioObj.isByteswapped()</value></param>
<param><key>swap_iq</key><value>radioObj.isIqSwapped()</value></param>
<param><key>tag_packets</key><value>False</value></param>
<param><key>vector</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wideband</value></param>
<param><key>label</key><value>Wideband</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wideband_0_0</value></param>
<param><key>label</key><value>Wideband</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<connection><source_block_id>ddcControl</source_block_id><sink_block_id>msg_sink_status_0_0</sink_block_id><source_key>freq</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ddcControl</source_block_id><sink_block_id>msg_sink_status_0</sink_block_id><source_key>status</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ddcControl</source_block_id><sink_block_id>udpSource</sink_block_id><source_key>udp</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>msg_src_control_0</source_block_id><sink_block_id>ddcControl</sink_block_id><source_key>out</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>msg_src_control_0_0</source_block_id><sink_block_id>ddcControl</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>udpSource</source_block_id><sink_block_id>msg_sink_status_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>udpSource</source_block_id><sink_block_id>ddcControl</sink_block_id><source_key>status</source_key><sink_key>udp</sink_key></connection>
</flow_graph>
