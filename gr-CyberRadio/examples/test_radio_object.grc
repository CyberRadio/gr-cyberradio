<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_radio_object</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Radio Object Test</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>funprober</value></param>
<param><key>block_id</key><value>levelProber</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_radio_object</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>radioConnType</key><value>tcp</value></param>
<param><key>radioControlPort</key><value>8617</value></param>
<param><key>radioHostname</key><value>ndr308</value></param>
<param><key>radioType</key><value>radioType</value></param>
<param><key>verbose</key><value>radioVerbose</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioObj_class</value></param>
<param><key>value</key><value>radioObj.__class__</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioParam</value></param>
<param><key>value</key><value>{"type":radioType,"host":radioHostname,"port":8617,"obj":radioObj}</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfFreqMhz</value></param>
<param><key>value</key><value>radioObj.getTunerFrequencyRange()[0]/1e6</value></param>
<param><key>label</key><value>RF Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>radioObj.getTunerFrequencyRange()[0]/1e6</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>radioObj.getTunerFrequencyRange()[-1]/1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>funprober</value></param>
<param><key>label</key><value>Signal Level</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>CyberRadio_generic_tuner_control_block_0_0</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>freq</key><value>int(rfFreqMhz)</value></param>
<param><key>index</key><value>1</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioParam</key><value>radioParam</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>comp2mag</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>levelProber</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioControlPort</value></param>
<param><key>label</key><value>Radio Control Port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8617</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioHostname</value></param>
<param><key>label</key><value>Radio Hostname</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr308</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioType</value></param>
<param><key>label</key><value>Radio Type</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr308</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioVerbose</value></param>
<param><key>label</key><value>Verbose Radio Connection</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sigSource</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>samp_rate/16</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttler</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>comp2mag</source_block_id><sink_block_id>levelProber</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigSource</source_block_id><sink_block_id>throttler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttler</source_block_id><sink_block_id>comp2mag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
