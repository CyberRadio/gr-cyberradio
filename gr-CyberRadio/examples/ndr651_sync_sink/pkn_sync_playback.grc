<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pkn_sync_playback</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig1</value></param>
<param><key>value</key><value>10**(sigLevel1/20)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig2</value></param>
<param><key>value</key><value>10**(sigLevel2/20)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sigLevel1</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>label</key><value>Signal Strength 1 (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sigLevel2</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>label</key><value>Signal Strength 2 (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>CyberRadio_NDR651_sync_sink</key>
<param><key>id</key><value>CyberRadio_NDR651_sync_sink_0</value></param>
<param><key>tenGbeIndex</key><value>1</value></param>
<param><key>centerFreqMHz1</key><value>center_freq_MHz_1</value></param>
<param><key>centerFreqMHz2</key><value>center_freq_MHz_2</value></param>
<param><key>channelRate</key><value>1</value></param>
<param><key>ducChannel1</key><value>1</value></param>
<param><key>ducChannel2</key><value>2</value></param>
<param><key>debug</key><value>1</value></param>
<param><key>digital_attenuationDB1</key><value>0</value></param>
<param><key>digital_attenuationDB2</key><value>0</value></param>
<param><key>frequencyOffsetMHz1</key><value>0</value></param>
<param><key>frequencyOffsetMHz2</key><value>0</value></param>
<param><key>groupIndex</key><value>1</value></param>
<param><key>mult1</key><value>1</value></param>
<param><key>mult2</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>rf_attenuationDB1</key><value>0</value></param>
<param><key>rf_attenuationDB2</key><value>0</value></param>
<param><key>radioHostname</key><value>ndr651</value></param>
<param><key>txChannel1</key><value>1</value></param>
<param><key>txChannel2</key><value>2</value></param>
<param><key>udp_port1</key><value>34567</value></param>
<param><key>udp_port2</key><value>34568</value></param>
<param><key>eth_index1</key><value>eth2</value></param>
<param><key>eth_index2</key><value>eth3</value></param>
</block>
<block>
<key>CyberRadio_vita_multifile_iq_source</key>
<param><key>id</key><value>CyberRadio_vita_multifile_iq_source_0</value></param>
<param><key>byte_swapped</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>filespecs</key><value>[file_2]</value></param>
<param><key>iq_scale_factor</key><value>1</value></param>
<param><key>iq_swapped</key><value>False</value></param>
<param><key>alphabetical</key><value>True</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>terminate_at_end</key><value>True</value></param>
<param><key>vita_header_size</key><value>9*4</value></param>
<param><key>payload_size</key><value>1024*4</value></param>
<param><key>vita_tail_size</key><value>1*4</value></param>
<param><key>vita_type</key><value>3</value></param>
</block>
<block>
<key>CyberRadio_vita_multifile_iq_source</key>
<param><key>id</key><value>CyberRadio_vita_multifile_iq_source_0_0</value></param>
<param><key>byte_swapped</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>filespecs</key><value>[file_1]</value></param>
<param><key>iq_scale_factor</key><value>1</value></param>
<param><key>iq_swapped</key><value>False</value></param>
<param><key>alphabetical</key><value>True</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>terminate_at_end</key><value>True</value></param>
<param><key>vita_header_size</key><value>9*4</value></param>
<param><key>payload_size</key><value>1024*4</value></param>
<param><key>vita_tail_size</key><value>1*4</value></param>
<param><key>vita_type</key><value>3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>2**13</value></param>
<param><key>n</key><value>2**13*100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>2**13</value></param>
<param><key>n</key><value>2**13*100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10**(sigLevel1/10)</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>10**(sigLevel2/10)</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>sig2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>sig1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq_MHz_1</value></param>
<param><key>label</key><value>Center Frequency 1</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1950</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq_MHz_2</value></param>
<param><key>label</key><value>Center Frequency 2</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1870</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_1</value></param>
<param><key>label</key><value>File 1</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/data/2/phil/records/col_1125_2015/f_1900_160003_1950M_51.2M.vita"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_2</value></param>
<param><key>label</key><value>File 2</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/data/1/phil/records/col_1125_2015/r_1900_160003_1870M_51.2M.vita"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*1e6</value></param>
<param><key>fc</key><value>center_freq_MHz_1*1e6</value></param>
<param><key>fftsize</key><value>2**13</value></param>
<param><key>label1</key><value>Tx 1</value></param>
<param><key>name</key><value>"Signal 1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate*1e6</value></param>
<param><key>fc</key><value>center_freq_MHz_2*1e6</value></param>
<param><key>fftsize</key><value>2**13</value></param>
<param><key>label1</key><value>Tx 1</value></param>
<param><key>name</key><value>"Signal 2"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Tx 1 I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Tx 1 Q</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Tx 2 I</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Tx 2 Q</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>2**12</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ymax</key><value>2**15</value></param>
<param><key>ymin</key><value>-2**15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate (MHz)</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>51.2</value></param>
</block>
<connection><source_block_id>CyberRadio_vita_multifile_iq_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_multifile_iq_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>CyberRadio_NDR651_sync_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>CyberRadio_NDR651_sync_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
