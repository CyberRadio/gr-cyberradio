<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr651_sync_sink</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1Freqz</value></param>
<param><key>value</key><value>-0.1</value></param>
<param><key>label</key><value>Tx 1 Discrete Frequency (samples/cycle)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.5</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch2Freqz</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>Tx 2 Discrete Frequency (samples/cycle)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.5</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>102.4</value></param>
<param><key>label</key><value>Sample Rate (MHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sigLevel1</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>Signal Strength 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sigLevel2</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>Signal Strength 2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>CyberRadio_NDR651_sync_sink</key>
<param><key>id</key><value>CyberRadio_NDR651_sync_sink_0</value></param>
<param><key>centerFreqMHz1</key><value>center_freq1</value></param>
<param><key>centerFreqMHz2</key><value>center_freq2</value></param>
<param><key>channelRate1</key><value>1</value></param>
<param><key>channelRate2</key><value>1</value></param>
<param><key>debug</key><value>1</value></param>
<param><key>digital_attenuationDB1</key><value>0</value></param>
<param><key>digital_attenuationDB2</key><value>0</value></param>
<param><key>frequencyOffsetMHz1</key><value>0</value></param>
<param><key>frequencyOffsetMHz2</key><value>0</value></param>
<param><key>groupIndex1</key><value>1</value></param>
<param><key>groupIndex2</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>rf_attenuationDB1</key><value>0</value></param>
<param><key>rf_attenuationDB2</key><value>0</value></param>
<param><key>radioHostname</key><value>ndr651</value></param>
<param><key>txChannel1</key><value>1</value></param>
<param><key>txChannel2</key><value>2</value></param>
<param><key>udp_port1</key><value>34567</value></param>
<param><key>udp_port2</key><value>34568</value></param>
<param><key>eth_index1</key><value>eth2</value></param>
<param><key>eth_index2</key><value>eth3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>2**(15*sigLevel1)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>2**(15*sigLevel2)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>ch1Freqz*2*math.pi</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_1</value></param>
<param><key>phase_inc</key><value>ch2Freqz*2*math.pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq1</value></param>
<param><key>label</key><value>Center Frequency 1 (MHz)</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq2</value></param>
<param><key>label</key><value>Center Frequency 2 (MHz)</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*1e6</value></param>
<param><key>fc</key><value>center_freq1*1e6</value></param>
<param><key>fftsize</key><value>2**12</value></param>
<param><key>label1</key><value>Tx 1</value></param>
<param><key>label2</key><value>Tx 2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Tx 1 I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Tx 1 Q</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Tx 2 I</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Tx 2 Q</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2**15</value></param>
<param><key>ymin</key><value>-2**15</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_rotator_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>CyberRadio_NDR651_sync_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_1</source_block_id><sink_block_id>CyberRadio_NDR651_sync_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
