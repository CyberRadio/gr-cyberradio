<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr804_display</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>radioType.upper() + " Display GUI " + " $Id: ndr804_display.grc 596 2016-04-22 17:26:43Z nathan.harter $"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alcDefault</value></param>
<param><key>value</key><value>{0:1, 1:0, 2:0}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alcLevelRange</value></param>
<param><key>value</key><value>[0,127] if radioType=="ndr328" else [0,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alcMultiplier</value></param>
<param><key>value</key><value>{0:1, 1:0, 2:0}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bfoRange</value></param>
<param><key>value</key><value>[-4000,4000] if radioType=="ndr328" else [0,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bwNb</value></param>
<param><key>value</key><value>nbddcBwSet[nbddcRateIndex]</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>calEnable</value></param>
<param><key>value</key><value>bool(calEnableCfg)</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>control_tabs@0:1,2,1,1</value></param>
<param><key>label</key><value>Enable Cal Signal</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>calEnableCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>enable</value></param>
<param><key>section</key><value>Cal</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>calEnable</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>calFreq</value></param>
<param><key>value</key><value>calFreqCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:1,3,1,2</value></param>
<param><key>label</key><value>Cal. Freq. Offset (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>+30</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>calFreqCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>Cal</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>calFreq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>configFile</value></param>
<param><key>value</key><value>configPath if configPath is not None else os.path.join("/public","ndrDemoGui","ndr804_display.%s.cfg"%radioType)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dagcDefault</value></param>
<param><key>value</key><value>{0:1, 1:0, 2:0}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dagcMultiplier</value></param>
<param><key>value</key><value>{0:1, 1:0, 2:0}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dagcRange</value></param>
<param><key>value</key><value>[0,127] if radioType=="ndr328" else [0,0]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>demodFftShift</value></param>
<param><key>value</key><value>demodFftShiftCfg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@4:0,1,1,1</value></param>
<param><key>label</key><value>Demod FFT Shift (dB)</value></param>
<param><key>min_len</key><value>201</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demodFftShiftCfg</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>15.4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>demod_fft_shift</value></param>
<param><key>section</key><value>GUI</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>demodFftShift</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>demodRssi</value></param>
<param><key>block_id</key><value>demodDisplay</value></param>
<param><key>function_name</key><value>get_rssi</value></param>
<param><key>value</key><value>"n/a"</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>demodRssiRsp</value></param>
<param><key>value</key><value>str(demodRssi)</value></param>
<param><key>gui_hint</key><value>1,4,1,2</value></param>
<param><key>label</key><value>Demod RSSI</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>demodRxRate</value></param>
<param><key>block_id</key><value>demodRxRateProbe</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>demodRxRateLabel</value></param>
<param><key>value</key><value>"%5.1f%%"%(100.0*demodRxRate/fsDemod)</value></param>
<param><key>gui_hint</key><value>control_tabs@1:1,2,1,1</value></param>
<param><key>label</key><value>Demod Rx Rate</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsAudio</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsDemod</value></param>
<param><key>value</key><value>8e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsNb</value></param>
<param><key>value</key><value>nbddcRateSet[nbddcRateIndex]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsWb</value></param>
<param><key>value</key><value>wbddcRateSet[wbddcRateIndex]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>iirAlpha</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>control_tabs@0:2,4,1,1</value></param>
<param><key>label</key><value>Display Alpha</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolatingFirTaps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, fsAudio, fsDemod/2, fsDemod, fsDemod/2, firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>iqFftGain</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@1:2,1,1,2</value></param>
<param><key>label</key><value>NB FFT Scale (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>100.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>iqRssi</value></param>
<param><key>block_id</key><value>nbIqDisplay</value></param>
<param><key>function_name</key><value>get_rssi</value></param>
<param><key>value</key><value>"n/a"</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>iqRssiRsp</value></param>
<param><key>value</key><value>str(iqRssi)</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>label</key><value>IQ RSSI</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logfile</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>os.path.join("/public","ndrDemoGui","%s.%s.log"%(radioType,datetime.datetime.now().strftime("%y%m%d-%H%M%S")))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbFrq</value></param>
<param><key>value</key><value>nbFrqCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:0,3,1,5</value></param>
<param><key>label</key><value>NB Freq (Hz)</value></param>
<param><key>min_len</key><value>int(40e6)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int( -20e6 )</value></param>
<param><key>step</key><value>int( 1e3 )</value></param>
<param><key>stop</key><value>int( +20e6 )</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbFrqCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>NBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbFrq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbIqFftShift</value></param>
<param><key>value</key><value>nbIqFftShiftCfg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@4:0,0,1,1</value></param>
<param><key>label</key><value>NB IQ FFT Shift (dB)</value></param>
<param><key>min_len</key><value>201</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbIqFftShiftCfg</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>9.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>nb_iq_fft_shift</value></param>
<param><key>section</key><value>GUI</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>nbIqFftShift</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcAlcLevel</value></param>
<param><key>value</key><value>alcMultiplier.get(nbddcAlcType,1)*nbddcAlcLevelSelection</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcAlcLevelSelection</value></param>
<param><key>value</key><value>nbddcAlcLevelSelectionCfg if radioType=="ndr328" else 0</value></param>
<param><key>gui_hint</key><value>control_tabs@2:1,2,1,3</value></param>
<param><key>label</key><value>"Alc Gain (Linear)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>alcLevelRange[0]</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>alcLevelRange[1]</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcAlcLevelSelectionCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>alcDefault.get(nbddcAlcTypeCfg)</value></param>
<param><key>option</key><value>alcLevel</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcAlcLevelSelection</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcAlcLevelSelection_0</value></param>
<param><key>value</key><value>nbddcAlcLevelSelectionCfg if radioType=="ndr328" else 0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,1,1,2</value></param>
<param><key>label</key><value>ALC Gain (Linear)</value></param>
<param><key>labels</key><value>[] if radioType=="ndr328" else ["n/a"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>range(128) if radioType=="ndr328" else [0]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcAlcType</value></param>
<param><key>value</key><value>nbddcAlcTypeCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:1,1,1,1</value></param>
<param><key>label</key><value>ALC Type</value></param>
<param><key>labels</key><value>["Manual","Slow","Fast",] if radioType=="ndr328" else ["n/a"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2] if radioType=="ndr328" else [0]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcAlcTypeCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>alcType</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcAlcType</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcBfo</value></param>
<param><key>value</key><value>nbddcBfoSelection if nbddcDemodType==0 else 0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcBfoCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bfo</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcBfo</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcBfoSelection</value></param>
<param><key>value</key><value>nbddcBfoCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:1,5,1,3</value></param>
<param><key>label</key><value>BFO (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>bfoRange[0]</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>bfoRange[1]</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcBwSet</value></param>
<param><key>value</key><value>radio.getNbddcBwSet(nbddcIndex)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcDagcLevel</value></param>
<param><key>value</key><value>dagcMultiplier.get(nbddcDagcType,1)*nbddcDagcLevelSelection</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcDagcLevelSelection</value></param>
<param><key>value</key><value>nbddcDagcLevelSelectionCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,2,1,3</value></param>
<param><key>label</key><value>"DAGC Gain (dB)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>dagcRange[0]</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>dagcRange[1]</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcDagcLevelSelectionCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>dagcDefault.get(nbddcDagcTypeCfg,0)</value></param>
<param><key>option</key><value>dagcLevel</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcDagcLevelSelection</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcDagcType</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,1,1,1</value></param>
<param><key>label</key><value>DAGC Type</value></param>
<param><key>labels</key><value>["Manual","Slow","Fast",] if radioType=="ndr328" else ["n/a"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2] if radioType=="ndr328" else [0]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcDagcTypeCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>dagcType</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcDagcType</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>nbddcDemodDcBlock</value></param>
<param><key>value</key><value>nbddcDemodDcBlockCfg</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,0,1,1</value></param>
<param><key>label</key><value>DC Block</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcDemodDcBlockCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>dcBlock</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>nbddcDemodDcBlock</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcDemodType</value></param>
<param><key>value</key><value>nbddcDemodTypeCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:1,0,1,1</value></param>
<param><key>label</key><value>Demod Type</value></param>
<param><key>labels</key><value>["None","CW", "AM","FM","LSB","USB"] if radioType=="ndr328" else ["None"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1, 0,1,2,3,4] if radioType=="ndr328" else [-1]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcDemodTypeCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>-1</value></param>
<param><key>option</key><value>type</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcDemodType</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcEnable</value></param>
<param><key>value</key><value>nbddcIndex&gt;=0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcEnableCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>True</value></param>
<param><key>option</key><value>enable</value></param>
<param><key>section</key><value>NBDDC</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>nbddcEnable</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>nbddcFormatProbe</value></param>
<param><key>block_id</key><value>nbddc_tabs</value></param>
<param><key>function_args</key><value>int(self.nbddcDemodType&gt;=0)</value></param>
<param><key>function_name</key><value>setCurrentIndex</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcIndex</value></param>
<param><key>value</key><value>nbddcIndexCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:0,0,1,1</value></param>
<param><key>label</key><value>NBDDC</value></param>
<param><key>labels</key><value>["Disabled",]+[str(i) for i in radio.getNbddcIndexRange()]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1,]+radio.getNbddcIndexRange()</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcIndexCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>radio.getNbddcIndexRange()[0]</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>NBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcIndex</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcRateIndex</value></param>
<param><key>value</key><value>nbddcRateIndexCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:0,1,1,1</value></param>
<param><key>label</key><value>NBDDC Rate</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>nbddcRateIndexOptions</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcRateIndexCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>nbddcRateIndexOptions[0]</value></param>
<param><key>option</key><value>rateIndex</value></param>
<param><key>section</key><value>NBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcRateIndexOptions</value></param>
<param><key>value</key><value>sorted(radio.getNbddcRateSet().keys())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcRateSet</value></param>
<param><key>value</key><value>radio.getNbddcRateSet(nbddcIndex)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>nbddcRxRate</value></param>
<param><key>block_id</key><value>nbddcRxRateProbe</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>nbddcRxRateLabel</value></param>
<param><key>value</key><value>"%5.1f%%"%(100.0*nbddcRxRate/fsNb)</value></param>
<param><key>gui_hint</key><value>control_tabs@1:1,1,1,1</value></param>
<param><key>label</key><value>NBDDC Rx Rate</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcSinadSRC</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@3:1,0,1,1</value></param>
<param><key>label</key><value>SINAD Src</value></param>
<param><key>labels</key><value>["CW","AM","FM1","FM2",] if radioType=="ndr328" else ["n/a"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2,3] if radioType=="ndr328" else [0]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcSquelchLevel</value></param>
<param><key>value</key><value>nbddcSquelchLevelCfg if radioType=="ndr328" else 0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,4,1,2</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>labels</key><value>[] if radioType=="ndr328" else ["n/a"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>range(-150,21) if radioType=="ndr328" else [0]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcSquelchLevel</value></param>
<param><key>value</key><value>nbddcSquelchLevelCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@2:2,5,1,3</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>squelchRange[0]</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>squelchRange[1]</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nbddcSquelchLevelCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>squelchRange[0]</value></param>
<param><key>option</key><value>squelchLevel</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcSquelchLevel</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>nbfsTxt</value></param>
<param><key>value</key><value>"%sHz @ %ssps"%(num_to_str(bwNb),num_to_str(fsNb))</value></param>
<param><key>gui_hint</key><value>control_tabs@2:0,2,1,1</value></param>
<param><key>label</key><value>Filter</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osDotSetCwd</value></param>
<param><key>value</key><value>os.chdir( os.path.expanduser( os.path.join( "~", "Desktop") ) )</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>otherNbddcEnable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>control_tabs@1:2,0,1,1</value></param>
<param><key>label</key><value>All NBDDCs?</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>plotColSpan</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>plotRowSpan</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio</value></param>
<param><key>value</key><value>crd.getRadioClass(radioType,)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>radioCmd</value></param>
<param><key>value</key><value>radioCmdCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@1:0,0,1,2</value></param>
<param><key>label</key><value>Command</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>radioCmdCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>*IDN?</value></param>
<param><key>option</key><value>cmd</value></param>
<param><key>section</key><value>Radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>radioCmd</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>radioRsp</value></param>
<param><key>block_id</key><value>ndrControlBlock</value></param>
<param><key>function_name</key><value>get_radio_rsp</value></param>
<param><key>value</key><value>""</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>radioRspDisplay</value></param>
<param><key>value</key><value>radioRsp</value></param>
<param><key>gui_hint</key><value>control_tabs@1:0,2,1,2</value></param>
<param><key>label</key><value>Response</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>radioRspTrigger</value></param>
<param><key>value</key><value>True</value></param>
<param><key>gui_hint</key><value>control_tabs@1:1,3,1,1</value></param>
<param><key>label</key><value>Send RSP</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rateProbeGain</value></param>
<param><key>value</key><value>2**-3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfAtten</value></param>
<param><key>value</key><value>rfAttenCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:1,0,1,2</value></param>
<param><key>label</key><value>RF Atten. (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int( radio.getTunerAttenuationRange()[0])</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int( radio.getTunerAttenuationRange()[1])</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rfAttenCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>Tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfAtten</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rfFilter</value></param>
<param><key>value</key><value>rfFilterCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:0,1,1,1</value></param>
<param><key>label0</key><value>LC</value></param>
<param><key>label1</key><value>SAW</value></param>
<param><key>label</key><value>IF Filter</value></param>
<param><key>labels</key><value>["Spectral","IQ"]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>options</key><value>[0,1]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rfFilterCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>filter</value></param>
<param><key>section</key><value>Tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfFilter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfFreq</value></param>
<param><key>value</key><value>rfFreqCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:0,2,1,3</value></param>
<param><key>label</key><value>RF Freq. (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int( radio.getTunerFrequencyRange()[0]/1e6 )</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>int( radio.getTunerFrequencyRange()[1]/1e6 )</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rfFreqCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1500</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>Tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfFreq</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rfIndex</value></param>
<param><key>value</key><value>rfIndexCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:0,0,1,1</value></param>
<param><key>label</key><value>Tuner</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radio.getTunerIndexRange()</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rfIndexCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>radio.getTunerIndexRange()[0]</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>Tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfIndex</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rssiResponse</value></param>
<param><key>block_id</key><value>ndrControlBlock</value></param>
<param><key>function_name</key><value>query_rssi</value></param>
<param><key>value</key><value>"-"</value></param>
<param><key>poll_rate</key><value>0.5 if radioType=="ndr328" else 0.0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rssiRspBox</value></param>
<param><key>value</key><value>rssiResponse</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>RSSI Rsp</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>specRate</value></param>
<param><key>value</key><value>specRateCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:2,3,1,1</value></param>
<param><key>label</key><value>Spectral Rate</value></param>
<param><key>labels</key><value>["Full Rate","10/second","100/second"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>range(3)</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>specRateCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>specRate</value></param>
<param><key>section</key><value>WBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>specRate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>specVecLen</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>squelchRange</value></param>
<param><key>value</key><value>[-150,21] if radioType=="ndr328" else [0,0]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wbIqFftShift</value></param>
<param><key>value</key><value>wbIqFftShiftCfg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>control_tabs@4:0,2,1,1</value></param>
<param><key>label</key><value>WB IQ FFT Shift (dB)</value></param>
<param><key>min_len</key><value>201</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbIqFftShiftCfg</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>wb_iq_fft_shift</value></param>
<param><key>section</key><value>GUI</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>wbIqFftShift</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcFormat</value></param>
<param><key>value</key><value>wbddcFormatCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:2,0,1,2</value></param>
<param><key>label</key><value>WBDDC Output</value></param>
<param><key>labels</key><value>["Disabled","Spectral","IQ"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1,0,1]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbddcFormatCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>format</value></param>
<param><key>section</key><value>WBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcFormat</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>wbddcFormatProbe</value></param>
<param><key>block_id</key><value>wbddc_tabs</value></param>
<param><key>function_args</key><value>self.wbddcFormat</value></param>
<param><key>function_name</key><value>setCurrentIndex</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcIndex</value></param>
<param><key>value</key><value>rfIndex if wbddcFormat in (0,1) else -1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbddcIndexCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>rfIndexCfg</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>WBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcIndex</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcRateIndex</value></param>
<param><key>value</key><value>wbddcRateIndexCfg</value></param>
<param><key>gui_hint</key><value>control_tabs@0:2,2,1,1</value></param>
<param><key>label</key><value>WBDDC Rate</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(wbddcRateSet.keys())</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>wbddcRateIndexCfg</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>sorted(wbddcRateSet.keys())[0]</value></param>
<param><key>option</key><value>rateIndex</value></param>
<param><key>section</key><value>WBDDC</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcRateIndex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcRateSet</value></param>
<param><key>value</key><value>radio.getWbddcRateSet()</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>wbddcRxRate</value></param>
<param><key>block_id</key><value>wbddcRxRateProbe</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>wbddcRxRateLabel</value></param>
<param><key>value</key><value>"%5.1f%%"%(100.0*wbddcRxRate/fsWb)</value></param>
<param><key>gui_hint</key><value>control_tabs@1:1,0,1,1</value></param>
<param><key>label</key><value>WBDDC Rx Rate (Rel. to expected)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcUdpPort</value></param>
<param><key>value</key><value>41000</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>audioInterpolator_8k_to_48k</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(fsAudio/fsDemod)</value></param>
<param><key>taps</key><value>interpolatingFirTaps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>logfile</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>32768/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0/32768</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1 if nbddcSinadSRC==0 else 0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1 if nbddcSinadSRC==1 else 0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1 if nbddcSinadSRC==2 else 0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_1</value></param>
<param><key>const</key><value>1 if nbddcSinadSRC==3 else 0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>57777</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>55001</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>2048*2</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>55002</value></param>
<param><key>type</key><value>float</value></param>
<param><key>psize</key><value>256*4</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>55002</value></param>
<param><key>type</key><value>float</value></param>
<param><key>psize</key><value>256*4</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>configPath</value></param>
<param><key>label</key><value>Config File Path</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>value</key><value>None</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>control_tabs</value></param>
<param><key>gui_hint</key><value>plotRowSpan,0,1,2*plotColSpan</value></param>
<param><key>label0</key><value>RF/WBDDC Parameters</value></param>
<param><key>label1</key><value>Commands/Misc.</value></param>
<param><key>label2</key><value>NBDDC Parameters</value></param>
<param><key>label3</key><value>Debug</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataPort</value></param>
<param><key>label</key><value>Radio NIC Index</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>qt_freq_time_sink_real</key>
<param><key>id</key><value>demodDisplay</value></param>
<param><key>centerFreq</key><value>0.0</value></param>
<param><key>enableRssi</key><value>True</value></param>
<param><key>fftGainLog</key><value>0.0</value></param>
<param><key>fftSizeN</key><value>10</value></param>
<param><key>fftPlotRange</key><value>[-140,0]</value></param>
<param><key>gui_hint</key><value>nbddc_tabs@1:0,0,1,1</value></param>
<param><key>hilbertFilterLength</key><value>10</value></param>
<param><key>label</key><value>"Demod"</value></param>
<param><key>rmsAvgGainExpInit</key><value>5</value></param>
<param><key>rmsGainRange</key><value>[0,11]</value></param>
<param><key>enableRssiDisplay</key><value>False</value></param>
<param><key>rssiPollRate</key><value>1.0</value></param>
<param><key>sampRate</key><value>fsDemod</value></param>
<param><key>enableSpectrum</key><value>True</value></param>
<param><key>enableTimeWaveform</key><value>True</value></param>
<param><key>updatePeriod</key><value>0.1</value></param>
<param><key>enableWaterfall</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>demodPayloadExtractor</value></param>
<param><key>m</key><value>256</value></param>
<param><key>n</key><value>552/2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>18</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>demodRxRateProbe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>100.0</value></param>
<param><key>alpha</key><value>rateProbeGain</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>demodShortToFloat</value></param>
<param><key>scale</key><value>(2**15)-1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>demodUdpSource</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>256*2+40</value></param>
<param><key>port</key><value>wbddcUdpPort+5</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>from_numpy_import_pi</value></param>
<param><key>import</key><value>from numpy import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hostname</value></param>
<param><key>label</key><value>Hostname/IP</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr308</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifname</value></param>
<param><key>label</key><value>10GbE NIC</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>eth6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_num_to_str</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import num_to_str</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_os_datetime</value></param>
<param><key>import</key><value>import os, datetime</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass_2(1,1,0.1,0.1, 60)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>iqUdpSink</value></param>
<param><key>ipaddr</key><value>localhost</value></param>
<param><key>port</key><value>57776</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1024*4</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qt_freq_time_sink_iq</key>
<param><key>id</key><value>nbIqDisplay</value></param>
<param><key>centerFreq</key><value>rfFreq*1e6 + nbFrq</value></param>
<param><key>enableRssi</key><value>True</value></param>
<param><key>fftGainLog</key><value>0.0</value></param>
<param><key>fftSizeN</key><value>10</value></param>
<param><key>fftPlotRange</key><value>[-140,0]</value></param>
<param><key>gui_hint</key><value>nbddc_tabs@0</value></param>
<param><key>label</key><value>"NBDDC"</value></param>
<param><key>rmsAvgGainExpInit</key><value>5</value></param>
<param><key>rmsGainRange</key><value>[0,11]</value></param>
<param><key>enableRssiDisplay</key><value>False</value></param>
<param><key>rssiPollRate</key><value>1.0</value></param>
<param><key>sampRate</key><value>fsNb</value></param>
<param><key>enableSpectrum</key><value>True</value></param>
<param><key>enableTimeWaveform</key><value>True</value></param>
<param><key>updatePeriod</key><value>0.1</value></param>
<param><key>enableWaterfall</key><value>True</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source</key>
<param><key>id</key><value>nbIqSource</value></param>
<param><key>byte_swapped</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>iq_scale_factor</key><value>1.0/((2**15)-1)</value></param>
<param><key>iq_swapped</key><value>False</value></param>
<param><key>payload_size</key><value>1024</value></param>
<param><key>port_list</key><value>[wbddcUdpPort+1]</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>vita_header_size</key><value>36</value></param>
<param><key>vita_tail_size</key><value>4</value></param>
<param><key>vita_type</key><value>3</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>nbddcRxRateProbe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>100.0</value></param>
<param><key>alpha</key><value>rateProbeGain</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>nbddc_tabs</value></param>
<param><key>gui_hint</key><value>0,plotColSpan,1,plotColSpan</value></param>
<param><key>label0</key><value>NBDDC Spectrum</value></param>
<param><key>label1</key><value>NB Demod Output</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>ndr_control_ndr_control</key>
<param><key>id</key><value>ndrControlBlock</value></param>
<param><key>calFrequency</key><value>(rfFreq+calFreq) if calEnable else 0</value></param>
<param><key>otherNbddcEnable</key><value>otherNbddcEnable</value></param>
<param><key>hostname</key><value>hostname</value></param>
<param><key>interface</key><value>str(ifname)</value></param>
<param><key>nbddcDagcLevel</key><value>nbddcDagcLevel</value></param>
<param><key>nbddcDagcType</key><value>nbddcDagcType</value></param>
<param><key>nbddcDemodAlcLevel</key><value>nbddcAlcLevel</value></param>
<param><key>nbddcDemodAlcType</key><value>nbddcAlcType</value></param>
<param><key>nbddcDemodBfo</key><value>nbddcBfo</value></param>
<param><key>nbddcDemodDcBlock</key><value>nbddcDemodDcBlock</value></param>
<param><key>nbddcDemodSquelchLevel</key><value>nbddcSquelchLevel</value></param>
<param><key>nbddcDemodType</key><value>nbddcDemodType</value></param>
<param><key>nbddcEnable</key><value>nbddcEnable</value></param>
<param><key>nbddcFreq</key><value>nbFrq</value></param>
<param><key>nbddcIndex</key><value>nbddcIndex</value></param>
<param><key>nbddcRate</key><value>nbddcRateIndex</value></param>
<param><key>nbddcPort</key><value>wbddcUdpPort+1</value></param>
<param><key>otherNbddcPort</key><value>wbddcUdpPort+2</value></param>
<param><key>radio_cmd</key><value>radioCmd</value></param>
<param><key>dataPort</key><value>dataPort</value></param>
<param><key>radioType</key><value>radioType</value></param>
<param><key>send_rsp_trigger</key><value>radioRspTrigger</value></param>
<param><key>tunerAtten</key><value>rfAtten</value></param>
<param><key>tunerFreq</key><value>rfFreq*1e6</value></param>
<param><key>tunerFilter</key><value>rfFilter</value></param>
<param><key>tunerIndex</key><value>rfIndex</value></param>
<param><key>verbose</key><value>bool(verbose)</value></param>
<param><key>wbddcEnable</key><value>wbddcIndex&gt;0</value></param>
<param><key>wbddcFormat</key><value>wbddcFormat</value></param>
<param><key>wbddcFreq</key><value>0.0</value></param>
<param><key>wbddcIndex</key><value>wbddcIndex</value></param>
<param><key>wbddcRate</key><value>wbddcRateIndex</value></param>
<param><key>wbddcPort</key><value>wbddcUdpPort</value></param>
<param><key>nbddcVitaLevel</key><value>2</value></param>
<param><key>specRate</key><value>specRate</value></param>
<param><key>wbddcVitaLevel</key><value>2</value></param>
</block>
<block>
<key>ndr_control_py_msg_strobe</key>
<param><key>id</key><value>ndr_control_py_msg_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rate</key><value>1.0</value></param>
<param><key>value</key><value>8e3 if (nbddcDemodType&gt;=0) else fsNb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioType</value></param>
<param><key>label</key><value>Tuner Index</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr328</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>spectralByteToFloat</value></param>
<param><key>scale</key><value>1.0</value></param>
<param><key>vlen</key><value>specVecLen</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>spectralGuiAveraging</value></param>
<param><key>alpha</key><value>2**-iirAlpha</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>specVecLen</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>spectralPayloadExtractor</value></param>
<param><key>m</key><value>4096</value></param>
<param><key>n</key><value>4136</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>36</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>spectralStreamToVector</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>specVecLen</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>spectralUdpSource</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>4136</value></param>
<param><key>port</key><value>wbddcUdpPort+4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>spectralVectorSink</value></param>
<param><key>gui_hint</key><value>wbddc_tabs@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>label1</key><value>Realtime</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>Average</value></param>
<param><key>name</key><value>Spectral Data</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>4096</value></param>
<param><key>x_axis_label</key><value>Frequency (MHz)</value></param>
<param><key>x_start</key><value>rfFreq-25.6</value></param>
<param><key>x_step</key><value>51.2/4096</value></param>
<param><key>x_units</key><value>MHz</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-90</value></param>
<param><key>y_axis_label</key><value>Amplitude (dBfs)</value></param>
<param><key>y_units</key><value>dBfs</value></param>
</block>
<block>
<key>blocks_file_descriptor_sink</key>
<param><key>id</key><value>stdoutFileDescriptor</value></param>
<param><key>fd</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>verbose</value></param>
<param><key>label</key><value>Verbose Driver Mode</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>qt_freq_time_sink_iq</key>
<param><key>id</key><value>wbIqDisplay</value></param>
<param><key>centerFreq</key><value>rfFreq*1e6</value></param>
<param><key>enableRssi</key><value>True</value></param>
<param><key>fftGainLog</key><value>0.0</value></param>
<param><key>fftSizeN</key><value>11</value></param>
<param><key>fftPlotRange</key><value>[-120,0]</value></param>
<param><key>gui_hint</key><value>wbddc_tabs@1</value></param>
<param><key>label</key><value>"WBDDC"</value></param>
<param><key>rmsAvgGainExpInit</key><value>5</value></param>
<param><key>rmsGainRange</key><value>[0,11]</value></param>
<param><key>enableRssiDisplay</key><value>True</value></param>
<param><key>rssiPollRate</key><value>1.0</value></param>
<param><key>sampRate</key><value>fsWb</value></param>
<param><key>enableSpectrum</key><value>True</value></param>
<param><key>enableTimeWaveform</key><value>False</value></param>
<param><key>updatePeriod</key><value>0.2</value></param>
<param><key>enableWaterfall</key><value>True</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source</key>
<param><key>id</key><value>wbIqSource</value></param>
<param><key>byte_swapped</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>iq_scale_factor</key><value>1.0/((2**15)-1)</value></param>
<param><key>iq_swapped</key><value>False</value></param>
<param><key>payload_size</key><value>4096</value></param>
<param><key>port_list</key><value>[wbddcUdpPort]</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>vita_header_size</key><value>36</value></param>
<param><key>vita_tail_size</key><value>4</value></param>
<param><key>vita_type</key><value>3</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>wbddcRxRateProbe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>125.0</value></param>
<param><key>alpha</key><value>rateProbeGain</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>wbddc_tabs</value></param>
<param><key>gui_hint</key><value>0,0,1,plotColSpan</value></param>
<param><key>label0</key><value>WBDDC Spectral Output</value></param>
<param><key>label1</key><value>WBDDC IQ Spectrum</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_udp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodPayloadExtractor</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodPayloadExtractor</source_block_id><sink_block_id>demodShortToFloat</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodShortToFloat</source_block_id><sink_block_id>audioInterpolator_8k_to_48k</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodShortToFloat</source_block_id><sink_block_id>blocks_udp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodShortToFloat</source_block_id><sink_block_id>demodDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodShortToFloat</source_block_id><sink_block_id>demodRxRateProbe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demodUdpSource</source_block_id><sink_block_id>demodPayloadExtractor</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbIqSource</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbIqSource</source_block_id><sink_block_id>iqUdpSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbIqSource</source_block_id><sink_block_id>nbIqDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbIqSource</source_block_id><sink_block_id>nbddcRxRateProbe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ndrControlBlock</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ndrControlBlock</source_block_id><sink_block_id>stdoutFileDescriptor</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ndr_control_py_msg_strobe_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msg</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spectralByteToFloat</source_block_id><sink_block_id>spectralGuiAveraging</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectralByteToFloat</source_block_id><sink_block_id>spectralVectorSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectralGuiAveraging</source_block_id><sink_block_id>spectralVectorSink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>spectralPayloadExtractor</source_block_id><sink_block_id>spectralStreamToVector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectralStreamToVector</source_block_id><sink_block_id>spectralByteToFloat</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectralUdpSource</source_block_id><sink_block_id>spectralPayloadExtractor</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbIqSource</source_block_id><sink_block_id>wbIqDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbIqSource</source_block_id><sink_block_id>wbddcRxRateProbe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
