<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr_qt_demo_gui</value></param>
<param><key>author</key><value>NH</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>NDR Demo GUI (QT)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_channelList</value></param>
<param><key>value</key><value>radioClass.getWbddcIndexRange()[0::2] if ch2_wb else radioClass.getWbddcIndexRange()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1_ddcFreq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,fftColSpan/2,1,fftColSpan/2</value></param>
<param><key>label</key><value>Freq (kHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>radioClass.getWbddcFrequencyRange()[0]/1e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>radioClass.getWbddcFrequencyRange()[1]/1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_fftSize</value></param>
<param><key>value</key><value>int( 2**wbfftSize )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_fs</value></param>
<param><key>value</key><value>ch1_rateSet[ch1_rateIndex]</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch1_fsLabel</value></param>
<param><key>value</key><value>"%sHz"%( num_to_str(ch1_fs) )</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>fs</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch1_index</value></param>
<param><key>value</key><value>ch1_channelList[0]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Ch 1</value></param>
<param><key>labels</key><value>(["Disabled"] if ch2_wb else [])+["WB%d"%i for i in ch1_channelList]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>([-1] if ch2_wb else [])+ch1_channelList if ch2_wb else ch1_channelList</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch1_index</value></param>
<param><key>value</key><value>ch1_channelList[0]</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>WBDDC</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>ch1_channelList</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch1_rateIndex</value></param>
<param><key>value</key><value>sorted(ch1_rateSet.keys())[0]</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Rate Index</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(ch1_rateSet.keys())</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_rateSet</value></param>
<param><key>value</key><value>radioClass.getWbddcRateSet()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1_rfAtten</value></param>
<param><key>value</key><value>int(radioClass.getTunerAttenuationRange()[0])</value></param>
<param><key>gui_hint</key><value>2,fftColSpan/2,1,fftColSpan/2</value></param>
<param><key>label</key><value>RF Atten (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioClass.getTunerAttenuationRange()[0])</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(radioClass.getTunerAttenuationRange()[1])</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1_rfFreq</value></param>
<param><key>value</key><value>int(sum(radioClass.getTunerFrequencyRange())/2e6)</value></param>
<param><key>gui_hint</key><value>2,0,1,fftColSpan/2</value></param>
<param><key>label</key><value>RF Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioClass.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>step</key><value>20</value></param>
<param><key>stop</key><value>int(radioClass.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_updateRate</value></param>
<param><key>value</key><value>wbfftRate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_channelList</value></param>
<param><key>value</key><value>radioClass.getWbddcIndexRange()[1::2] if ch2_wb else radioClass.getNbddcIndexRange()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch2_ddcFreq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,fftColSpan+fftColSpan/2,1,fftColSpan/2</value></param>
<param><key>label</key><value>Freq (kHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(radioClass.getWbddcFrequencyRange() if ch2_wb else radioClass.getNbddcFrequencyRange())[0]/1e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>(radioClass.getWbddcFrequencyRange() if ch2_wb else radioClass.getNbddcFrequencyRange())[1]/1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_fftSize</value></param>
<param><key>value</key><value>ch1_fftSize if ch2_wb else ch1_fftSize/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_fs</value></param>
<param><key>value</key><value>ch2_rateSet[ch2_rateIndex]</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch2_fsLabel</value></param>
<param><key>value</key><value>"%sHz"%( num_to_str(ch2_fs) )</value></param>
<param><key>gui_hint</key><value>1,fftColSpan+2,1,1</value></param>
<param><key>label</key><value>fs</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch2_index</value></param>
<param><key>value</key><value>ch2_channelList[0]</value></param>
<param><key>gui_hint</key><value>1,fftColSpan+0,1,1</value></param>
<param><key>label</key><value>"%sDDC"%("WB" if ch2_wb else "NB")</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>ch2_channelList</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch2_index_0</value></param>
<param><key>value</key><value>ch2_channelList[0]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,fftColSpan+0,1,1</value></param>
<param><key>label</key><value>Ch 2</value></param>
<param><key>labels</key><value>["Disabled",]+["%s%d"%("WB" if ch2_wb else "NB",i) for i in ch2_channelList]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[-1]+ch2_channelList</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch2_rateIndex</value></param>
<param><key>value</key><value>sorted(ch2_rateSet.keys())[0]</value></param>
<param><key>gui_hint</key><value>1,fftColSpan+1,1,1</value></param>
<param><key>label</key><value>Rate Index</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(ch2_rateSet.keys())</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_rateSet</value></param>
<param><key>value</key><value>radioClass.getWbddcRateSet() if ch2_wb else radioClass.getNbddcRateSet()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch2_rfAtten</value></param>
<param><key>value</key><value>ch2_rfAttenRange[0]</value></param>
<param><key>gui_hint</key><value>2,fftColSpan+fftColSpan/2,1,fftColSpan/2</value></param>
<param><key>label</key><value>RF Atten (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>ch2_rfAttenRange[0]</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>ch2_rfAttenRange[1]</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_rfAttenRange</value></param>
<param><key>value</key><value>[int(i) for i in radioClass.getTunerAttenuationRange()] if ch2_wb else [0,0]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch2_rfFreq</value></param>
<param><key>value</key><value>int(sum(radioClass.getTunerFrequencyRange())/2e6) if ch2_wb else 0</value></param>
<param><key>gui_hint</key><value>2,fftColSpan+0,1,fftColSpan/2</value></param>
<param><key>label</key><value>RF Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioClass.getTunerFrequencyRange()[0]/1e6) if ch2_wb else 0</value></param>
<param><key>step</key><value>20</value></param>
<param><key>stop</key><value>int(radioClass.getTunerFrequencyRange()[1]/1e6) if ch2_wb else 0</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_rfFreqRange</value></param>
<param><key>value</key><value>[int(i/1e6) for i in radioClass.getTunerFrequencyRange()] if ch2_wb else [0,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_updateRate</value></param>
<param><key>value</key><value>ch1_updateRate if ch2_wb else 4*ch1_updateRate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch2_wb</value></param>
<param><key>value</key><value>bool(wideband2) or radioType.strip().lower() in ("ndr304","ndr472")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftColSpan</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ipAddress</value></param>
<param><key>value</key><value>macAndIpList[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logfile</value></param>
<param><key>value</key><value>os.path.join("/public","ndrDemoGui","ndrCmd.%s.log"%datetime.datetime.now().strftime("%y%m%d-%H%M%S"))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>macAndIpList</value></param>
<param><key>value</key><value>crd.getInterfaceAddresses(ifname)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radioClass</value></param>
<param><key>value</key><value>crd.getRadioClass(radioType,)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>radioCmd</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>3,0,1,2</value></param>
<param><key>label</key><value>Manual Command</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>radioRsp</value></param>
<param><key>block_id</key><value>ndrDemoControlBlock</value></param>
<param><key>function_name</key><value>get_radio_rsp</value></param>
<param><key>value</key><value>""</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>radioRspDisplay</value></param>
<param><key>value</key><value>radioRsp</value></param>
<param><key>gui_hint</key><value>3,2,1,2*fftColSpan-2</value></param>
<param><key>label</key><value>Command Response</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udpPortList</value></param>
<param><key>value</key><value>[basePort,basePort+1]</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0</value></param>
<param><key>bytes_per_packet</key><value>radioClass.getVitaHeaderSize()+radioClass.getVitaPayloadSize()+radioClass.getVitaTailSize()</value></param>
<param><key>header_byte_offset</key><value>radioClass.getVitaHeaderSize()</value></param>
<param><key>port</key><value>udpPortList[0]</value></param>
<param><key>samples_per_packet</key><value>radioClass.getVitaPayloadSize()/4</value></param>
<param><key>src_ip</key><value>macAndIpList[1]</value></param>
<param><key>swap_bytes</key><value>radioClass.isByteswapped()</value></param>
<param><key>tag_packets</key><value>False</value></param>
<param><key>vector</key><value>False</value></param>
</block>
<block>
<key>CyberRadio_vita_udp_rx</key>
<param><key>id</key><value>CyberRadio_vita_udp_rx_0_0</value></param>
<param><key>bytes_per_packet</key><value>radioClass.getVitaHeaderSize()+radioClass.getVitaPayloadSize()+radioClass.getVitaTailSize()</value></param>
<param><key>header_byte_offset</key><value>radioClass.getVitaHeaderSize()</value></param>
<param><key>port</key><value>udpPortList[1]</value></param>
<param><key>samples_per_packet</key><value>radioClass.getVitaPayloadSize()/4</value></param>
<param><key>src_ip</key><value>macAndIpList[1]</value></param>
<param><key>swap_bytes</key><value>radioClass.isByteswapped()</value></param>
<param><key>tag_packets</key><value>False</value></param>
<param><key>vector</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>basePort</value></param>
<param><key>label</key><value>Base UDP Port for IF Streaming</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>22200</value></param>
</block>
<block>
<key>blocks_file_descriptor_sink</key>
<param><key>id</key><value>blocks_file_descriptor_sink_0</value></param>
<param><key>fd</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>logfile</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>ch1_fftDisplay</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>ch1_fs</value></param>
<param><key>fc</key><value>ch1_rfFreq*1e6 + ch1_ddcFreq*1e3</value></param>
<param><key>fftsize</key><value>ch1_fftSize</value></param>
<param><key>gui_hint</key><value>ch1_tabs@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>Channel 1 (Wideband)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/ch1_updateRate</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source</key>
<param><key>id</key><value>ch1_iqSource</value></param>
<param><key>byte_swapped</key><value>radioClass.isByteswapped()</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>macAndIpList[1]</value></param>
<param><key>iq_scale_factor</key><value>1.0/((2**15)-1)</value></param>
<param><key>iq_swapped</key><value>radioClass.isIqSwapped()</value></param>
<param><key>payload_size</key><value>radioClass.getVitaPayloadSize()</value></param>
<param><key>port_list</key><value>[ udpPortList[0] ]</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>vita_header_size</key><value>radioClass.getVitaHeaderSize()</value></param>
<param><key>vita_tail_size</key><value>radioClass.getVitaTailSize()</value></param>
<param><key>vita_type</key><value>vitaLevel</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>ch1_tabs</value></param>
<param><key>gui_hint</key><value>0,0,1,fftColSpan</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Waterfall</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>ch2_fftDisplay</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>ch2_fs</value></param>
<param><key>fc</key><value>(ch2_rfFreq if ch2_wb else ch1_rfFreq)*1e6 + ch2_ddcFreq*1e3</value></param>
<param><key>fftsize</key><value>ch2_fftSize</value></param>
<param><key>gui_hint</key><value>ch2_tabs@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>"Channel 2 (%sband)"%("Wide" if ch2_wb else "Narrow")</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/ch2_updateRate</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>CyberRadio_vita_iq_source</key>
<param><key>id</key><value>ch2_iqSource</value></param>
<param><key>byte_swapped</key><value>radioClass.isByteswapped()</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>macAndIpList[1]</value></param>
<param><key>iq_scale_factor</key><value>1.0/((2**15)-1)</value></param>
<param><key>iq_swapped</key><value>radioClass.isIqSwapped()</value></param>
<param><key>payload_size</key><value>radioClass.getVitaPayloadSize()</value></param>
<param><key>port_list</key><value>[ udpPortList[1] ]</value></param>
<param><key>tagged</key><value>False</value></param>
<param><key>vita_header_size</key><value>radioClass.getVitaHeaderSize()</value></param>
<param><key>vita_tail_size</key><value>radioClass.getVitaTailSize()</value></param>
<param><key>vita_type</key><value>vitaLevel</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>ch2_tabs</value></param>
<param><key>gui_hint</key><value>0,fftColSpan,1,fftColSpan</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataPort</value></param>
<param><key>label</key><value>Radio NIC Index</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hostnameOrDevice</value></param>
<param><key>label</key><value>Radio Hostname or Serial Device name</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/dev/ndr47x</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifname</value></param>
<param><key>label</key><value>10GbE NIC</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>eth6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_crd</value></param>
<param><key>import</key><value>import CyberRadioDriver as crd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_datetime</value></param>
<param><key>import</key><value>import os, datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_num_to_str</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import num_to_str</value></param>
</block>
<block>
<key>CyberRadio_NDR_demo_control</key>
<param><key>id</key><value>ndrDemoControlBlock</value></param>
<param><key>cal_freq</key><value>0.0</value></param>
<param><key>ddc1_data_port</key><value>dataPort</value></param>
<param><key>ddc1_enable</key><value>True</value></param>
<param><key>ddc1_freq</key><value>ch1_ddcFreq*1e3</value></param>
<param><key>ddc1_index</key><value>ch1_index</value></param>
<param><key>ddc1_rate_index</key><value>ch1_rateIndex</value></param>
<param><key>ddc1_rf_source</key><value>-1</value></param>
<param><key>ddc1_udp_port</key><value>udpPortList[0]</value></param>
<param><key>ddc1_vita49_level</key><value>vitaLevel</value></param>
<param><key>ddc1_wideband</key><value>True</value></param>
<param><key>ddc2_data_port</key><value>dataPort</value></param>
<param><key>ddc2_enable</key><value>True</value></param>
<param><key>ddc2_freq</key><value>1e3*ch2_ddcFreq</value></param>
<param><key>ddc2_index</key><value>ch2_index</value></param>
<param><key>ddc2_rate_index</key><value>ch2_rateIndex</value></param>
<param><key>ddc2_rf_source</key><value>-1 if ch2_wb else ch1_index</value></param>
<param><key>ddc2_udp_port</key><value>udpPortList[1]</value></param>
<param><key>ddc2_vita49_level</key><value>vitaLevel</value></param>
<param><key>ddc2_wideband</key><value>ch2_wb</value></param>
<param><key>interface_dict</key><value>{dataPort:str(ifname)}</value></param>
<param><key>other_args</key><value>{}</value></param>
<param><key>radio_cmd</key><value>str(radioCmd)</value></param>
<param><key>radio_hostname</key><value>str(hostnameOrDevice)</value></param>
<param><key>radio_port</key><value>int(udpPortOrBaudrate)</value></param>
<param><key>radio_type</key><value>str(radioType)</value></param>
<param><key>tuner1_atten</key><value>ch1_rfAtten</value></param>
<param><key>tuner1_freq</key><value>float( 1e6*ch1_rfFreq )</value></param>
<param><key>tuner1_index</key><value>ch1_index</value></param>
<param><key>tuner2_atten</key><value>ch2_rfAtten</value></param>
<param><key>tuner2_freq</key><value>float( 1e6*ch2_rfFreq )</value></param>
<param><key>tuner2_index</key><value>ch2_index if ch2_wb else -1</value></param>
<param><key>verbose</key><value>bool(verbose)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>ch2_tabs@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>ch2_fs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>ch1_fs</value></param>
<param><key>fc</key><value>ch1_rfFreq*1e6 + ch1_ddcFreq*1e3</value></param>
<param><key>fftsize</key><value>ch1_fftSize</value></param>
<param><key>gui_hint</key><value>ch1_tabs@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>Ch 1 (Wideband)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/ch1_updateRate</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioType</value></param>
<param><key>label</key><value>Radio Type</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr304</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udpPortOrBaudrate</value></param>
<param><key>label</key><value>Radio TCP/UDP Control Port or Baudrate</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>921600</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>verbose</value></param>
<param><key>label</key><value>Verbose Driver Mode</value></param>
<param><key>short_id</key><value>V</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vitaLevel</value></param>
<param><key>label</key><value>Vita 49 Level</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wbfftRate</value></param>
<param><key>label</key><value>Wideband FFT Update Rate (Hz)</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wbfftSize</value></param>
<param><key>label</key><value>Wideband FFT Size (2^x)</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wideband2</value></param>
<param><key>label</key><value>Set 2nd channel to wideband</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>CyberRadio_vita_udp_rx_0</source_block_id><sink_block_id>ch1_fftDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>ch2_fftDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_vita_udp_rx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch1_iqSource</source_block_id><sink_block_id>ch1_fftDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch1_iqSource</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch2_iqSource</source_block_id><sink_block_id>ch2_fftDisplay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch2_iqSource</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ndrDemoControlBlock</source_block_id><sink_block_id>blocks_file_descriptor_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ndrDemoControlBlock</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
