<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simple_spectral_display</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Simple Spectral Display</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_dynRange</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>150</value></param>
<param><key>option</key><value>dyn_range</value></param>
<param><key>section</key><value>display</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>dynRange</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_iirAvgExp</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(3)</value></param>
<param><key>option</key><value>iirAvgExp</value></param>
<param><key>section</key><value>gui</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>iirAvgExp</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_nbddcFreqHz</value></param>
<param><key>config_file</key><value>os.path.expanduser("~/.wbSpecSearch.cfg")</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>nbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcFreqHz</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_nbddcIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>radioObj.getNbddcIndexRange()[0]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>nbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcIndex</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_nbddcRateIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>sorted(nbddcRateSet.keys())[0]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>nbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nbddcRateIndex</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_refLevel</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ref_level</value></param>
<param><key>section</key><value>display</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>refLevel</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_rfFreqMhz</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rfFreqMhz</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_tunerAtten</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>int(radioObj.getTunerAttenuationRange()[0])</value></param>
<param><key>option</key><value>atten</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>tunerAtten</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_tunerIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>radioObj.getTunerIndexRange()[0]</value></param>
<param><key>option</key><value>index</value></param>
<param><key>section</key><value>tuner</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>tunerIndex</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_wbddcRateIndex</value></param>
<param><key>config_file</key><value>configFilePath</value></param>
<param><key>value</key><value>sorted(wbddcRateSet.keys())[0]</value></param>
<param><key>option</key><value>rate_index</value></param>
<param><key>section</key><value>wbddc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>wbddcRateIndex</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>clearEnable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>label</key><value>Clear Max</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>clearEnable</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>bool(clearButton)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>configFilePath</value></param>
<param><key>value</key><value>os.path.expanduser( os.path.join("~",".simple_spectral_display.%s.cfg"%(radioObj.name.lower(),)) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dispSize</value></param>
<param><key>value</key><value>fftSize</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dynRange</value></param>
<param><key>value</key><value>cfg_dynRange</value></param>
<param><key>gui_hint</key><value>wbTabs@0:1,1,1,1</value></param>
<param><key>label</key><value>"Dyn.\nRange\n(dB)"</value></param>
<param><key>min_len</key><value>(195/5)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftSize</value></param>
<param><key>value</key><value>int(2**fftSizeExponent)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftWindow</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>scipy.signal.get_window(fftWindowType,fftSize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framesPerBlock</value></param>
<param><key>value</key><value>float(framesPerSecond)/fftRate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framesPerFft</value></param>
<param><key>value</key><value>int( numpy.round( float(fftSize)/samplesPerFrame ) )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framesPerSecond</value></param>
<param><key>value</key><value>float(wbSampleRate)/float(samplesPerFrame)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framesToSkip</value></param>
<param><key>value</key><value>int(numpy.round(framesPerBlock-framesPerFft))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iirAlpha</value></param>
<param><key>value</key><value>2.0**(float(-iirAvgExp))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>iirAvgExp</value></param>
<param><key>value</key><value>cfg_iirAvgExp</value></param>
<param><key>gui_hint</key><value>wbTabs@0:2,1,1,1</value></param>
<param><key>label</key><value>Avg.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbSampleRate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>nbddcRateSet[nbddcRateIndex]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcBwSet</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>dict( [(k,v) for k,v in radioObj.getNbddcBwSet().iteritems() if radioObj.getDdcDataFormat(False).get(k,"iq")!="real"] )</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>nbddcEnable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>wbTabs@2</value></param>
<param><key>label</key><value>NBDDC Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcEnable</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbddcFreqHz</value></param>
<param><key>value</key><value>cfg_nbddcFreqHz</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>wbTabs@2:2,0,1,3</value></param>
<param><key>label</key><value>NBDDC Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getNbddcFrequencyRange()[0])</value></param>
<param><key>step</key><value>1250</value></param>
<param><key>stop</key><value>int(radioObj.getNbddcFrequencyRange()[1])</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcIndex</value></param>
<param><key>value</key><value>cfg_nbddcIndex</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>wbTabs@2:1,0,1,1</value></param>
<param><key>label</key><value>NBDDC Index</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radioObj.getNbddcIndexRange()</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>nbddcRateIndex</value></param>
<param><key>value</key><value>cfg_nbddcRateIndex</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>wbTabs@2:1,1,1,1</value></param>
<param><key>label</key><value>NBDDC Index</value></param>
<param><key>labels</key><value>["%d: %sHz @ %ssps"%(k,num_to_str(nbddcBwSet[k]),num_to_str(nbddcRateSet[k])) for k in sorted(nbddcRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(nbddcRateSet.keys())</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbddcRateSet</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>radioObj.getNbddcRateSet()</value></param>
</block>
<block>
<key>variable_radio_object</key>
<param><key>id</key><value>radioObj</value></param>
<param><key>connect</key><value>True</value></param>
<param><key>radioHostname</key><value>radioHostname</value></param>
<param><key>radioType</key><value>radioType</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>refLevel</value></param>
<param><key>value</key><value>cfg_refLevel</value></param>
<param><key>gui_hint</key><value>wbTabs@0:0,1,1,1</value></param>
<param><key>label</key><value>"Ref.\nLevel\n(dB)"</value></param>
<param><key>min_len</key><value>(130/5)+1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>+10</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resetTrigger</value></param>
<param><key>value</key><value>any([clearEnable,rfFreqMhz,tunerAtten,])</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfFreqMhz</value></param>
<param><key>value</key><value>cfg_rfFreqMhz</value></param>
<param><key>gui_hint</key><value>wbTabs@0:3,0,1,1</value></param>
<param><key>label</key><value>Tuner Freq (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerFrequencyRange()[0]/1e6)</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>int(radioObj.getTunerFrequencyRange()[1]/1e6)</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samplesPerFrame</value></param>
<param><key>value</key><value>int( radioObj.getVitaPayloadSize()/4 )</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tunerAtten</value></param>
<param><key>value</key><value>cfg_tunerAtten</value></param>
<param><key>gui_hint</key><value>wbTabs@0:3,1,1,1</value></param>
<param><key>label</key><value>"Tuner\nAtten.\n(dB)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>int(radioObj.getTunerAttenuationRange()[0])</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(radioObj.getTunerAttenuationRange()[1])</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>tunerIndex</value></param>
<param><key>value</key><value>cfg_tunerIndex</value></param>
<param><key>gui_hint</key><value>wbTabs@2:0,0,1,1</value></param>
<param><key>label</key><value>Tuner Index</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>radioObj.getTunerIndexRange()</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udpBasePort</value></param>
<param><key>value</key><value>44000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbSampleRate</value></param>
<param><key>value</key><value>wbddcRateSet[wbddcRateIndex]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcBwSet</value></param>
<param><key>value</key><value>dict( [(k,v) for k,v in radioObj.getWbddcBwSet().iteritems() if radioObj.getDdcDataFormat(True).get(k,"iq")!="real"] )</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>wbddcEnable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>wbTabs@2</value></param>
<param><key>label</key><value>WBDDC Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcEnable</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wbddcRateIndex</value></param>
<param><key>value</key><value>cfg_wbddcRateIndex</value></param>
<param><key>gui_hint</key><value>wbTabs@2:0,1,1,1</value></param>
<param><key>label</key><value>WBDDC Sample Rate</value></param>
<param><key>labels</key><value>["%d: %sHz @ %ssps"%(k,num_to_str(wbddcBwSet[k]),num_to_str(wbddcRateSet[k])) for k in sorted(wbddcRateSet.keys())]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>sorted(wbddcRateSet.keys())</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbddcRateSet</value></param>
<param><key>value</key><value>dict( [(k,v) for k,v in radioObj.getWbddcRateSet().iteritems() if radioObj.getDdcDataFormat(True).get(k,"iq")!="real"] )</value></param>
</block>
<block>
<key>CyberRadio_generic_ddc_control_block</key>
<param><key>id</key><value>CyberRadio_generic_ddc_control_block_0</value></param>
<param><key>activeRepeatPackets</key><value>1</value></param>
<param><key>enable</key><value>wbddcEnable</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>index</key><value>tunerIndex</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rate</key><value>wbddcRateIndex</value></param>
<param><key>dipIndex</key><value>-1</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>udpPort</key><value>udpBasePort</value></param>
<param><key>localInterface</key><value>""</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>phaseOffset</key><value>0.0</value></param>
<param><key>rfFreq</key><value>0</value></param>
<param><key>rfSource</key><value>tunerIndex</value></param>
<param><key>radioInterface</key><value>-1</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>totalRepeatPackets</key><value>1</value></param>
<param><key>wideband</key><value>True</value></param>
</block>
<block>
<key>CyberRadio_generic_tuner_control_block</key>
<param><key>id</key><value>CyberRadio_generic_tuner_control_block_0</value></param>
<param><key>attenuation</key><value>tunerAtten</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>freq</key><value>rfFreqMhz</value></param>
<param><key>filter</key><value>1</value></param>
<param><key>index</key><value>tunerIndex</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
<param><key>group</key><value>None</value></param>
</block>
<block>
<key>CyberRadio_log_mag_fft</key>
<param><key>id</key><value>CyberRadio_log_mag_fft_0</value></param>
<param><key>numInputs</key><value>1</value></param>
<param><key>iirAlpha</key><value>iirAlpha if resetTrigger else iirAlpha</value></param>
<param><key>fftSize</key><value>fftSize</value></param>
<param><key>resetOnAlphaChange</key><value>True</value></param>
<param><key>secondaryOutput</key><value>log_mag_unfiltered</value></param>
<param><key>windowType</key><value>"blackmanharris"</value></param>
</block>
<block>
<key>CyberRadio_py_peak_hold</key>
<param><key>id</key><value>CyberRadio_py_peak_hold_0</value></param>
<param><key>clearEnable</key><value>True if resetTrigger else False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>otherArgs</key><value>{}</value></param>
<param><key>vecLen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vlen</key><value>dispSize</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1_0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
<param><key>vlen</key><value>fftSize</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controlTabs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftRate</value></param>
<param><key>label</key><value>fftRate</value></param>
<param><key>short_id</key><value>R</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftSizeExponent</value></param>
<param><key>label</key><value>FFT Size (&lt;=20)</value></param>
<param><key>short_id</key><value>F</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftWindowType</value></param>
<param><key>label</key><value>FFT Window Type</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>hann</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fftSize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>fftWindow/numpy.sum(fftWindow)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_eng_notation_start</value></param>
<param><key>import</key><value>from gnuradio.eng_notation import *</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>localDataInterface</value></param>
<param><key>label</key><value>Local Data Interface</value></param>
<param><key>short_id</key><value>D</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>nbTabs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label0</key><value>Frequency</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>label2</key><value>FM Demod</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>wbTabs@0:0,0,3,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"yellow"</value></param>
<param><key>label1</key><value>Realtime</value></param>
<param><key>color2</key><value>"cyan"</value></param>
<param><key>label2</key><value>Average</value></param>
<param><key>color3</key><value>"magenta"</value></param>
<param><key>label3</key><value>Peak Hold</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>vlen</key><value>dispSize</value></param>
<param><key>x_axis_label</key><value>Frequency (MHz)</value></param>
<param><key>x_start</key><value>rfFreqMhz-wbSampleRate/2e6</value></param>
<param><key>x_step</key><value>wbSampleRate/1e6/fftSize</value></param>
<param><key>x_units</key><value>MHz</value></param>
<param><key>ymax</key><value>refLevel</value></param>
<param><key>ymin</key><value>refLevel-dynRange</value></param>
<param><key>y_axis_label</key><value>Magnitude (dBfs)</value></param>
<param><key>y_units</key><value>dBfs</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>wbTabs@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>vlen</key><value>dispSize</value></param>
<param><key>x_axis_label</key><value>Sample</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0/1024</value></param>
<param><key>x_units</key><value>Frame</value></param>
<param><key>ymax</key><value>+1</value></param>
<param><key>ymin</key><value>-1</value></param>
<param><key>y_axis_label</key><value>Amplitude</value></param>
<param><key>y_units</key><value>V</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioDataPort</value></param>
<param><key>label</key><value>Radio Data Port (-1 for auto select)</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioHostname</value></param>
<param><key>label</key><value>Radio Hostname</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr358</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radioType</value></param>
<param><key>label</key><value>Radio Type</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ndr358</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>various_imports</value></param>
<param><key>import</key><value>import os, numpy, json, scipy.signal</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>wbTabs</value></param>
<param><key>gui_hint</key><value>0,0,2,3</value></param>
<param><key>label0</key><value>High-Res Wideband</value></param>
<param><key>label1</key><value>Time Plot</value></param>
<param><key>label2</key><value>Control</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>CyberRadio_snapshot_vector_source</key>
<param><key>id</key><value>wb_rx_source_snap</value></param>
<param><key>block_rate</key><value>fftRate</value></param>
<param><key>block_size</key><value>fftSize</value></param>
<param><key>ip</key><value>0.0.0.0</value></param>
<param><key>port</key><value>udpBasePort</value></param>
<param><key>radioObj</key><value>radioObj</value></param>
</block>
<connection><source_block_id>CyberRadio_generic_ddc_control_block_0</source_block_id><sink_block_id>blocks_message_debug_1_0</sink_block_id><source_key>status</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>CyberRadio_generic_ddc_control_block_0</source_block_id><sink_block_id>wb_rx_source_snap</sink_block_id><source_key>udp</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>CyberRadio_log_mag_fft_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>CyberRadio_log_mag_fft_0</source_block_id><sink_block_id>CyberRadio_py_peak_hold_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_log_mag_fft_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CyberRadio_py_peak_hold_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wb_rx_source_snap</source_block_id><sink_block_id>CyberRadio_log_mag_fft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wb_rx_source_snap</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wb_rx_source_snap</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wb_rx_source_snap</source_block_id><sink_block_id>CyberRadio_generic_ddc_control_block_0</sink_block_id><source_key>status</source_key><sink_key>udp</sink_key></connection>
</flow_graph>
