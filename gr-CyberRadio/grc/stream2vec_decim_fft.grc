<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stream2vec_decim_fft</value></param>
<param><key>category</key><value>[CyberRadio]/Test/Local</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Stream 2 Vec Decim. FFT</value></param>
</block>
<block>
<key>CyberRadio_vector_nlog10_ff</key>
<param><key>id</key><value>CyberRadio_vector_nlog10_ff_0</value></param>
<param><key>vlen</key><value>vecLen</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>blocks_stream_to_vector_decimator</key>
<param><key>id</key><value>blocks_stream_to_vector_decimator_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>vecLen</value></param>
<param><key>vec_rate</key><value>vecRate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enableFft</value></param>
<param><key>label</key><value>FFT Output Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enableFftLogMag</value></param>
<param><key>label</key><value>FFT Log Mag. Output Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enablePhase</value></param>
<param><key>label</key><value>Phase Output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftWindow</value></param>
<param><key>label</key><value>FFT Window</value></param>
<param><key>value</key><value>window.blackmanharris(1024)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>vecLen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>fftWindow</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iirAlpha</value></param>
<param><key>label</key><value>Avg Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0**-3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>IQ</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>FFT</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>FFT Log Mag</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Phase</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0e6</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>iirAlpha</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>vecLen</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vecLen</value></param>
<param><key>label</key><value>Vector/FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**11</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vecRate</value></param>
<param><key>label</key><value>Vector Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<connection><source_block_id>CyberRadio_vector_nlog10_ff_0</source_block_id><sink_block_id>out2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>out3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0</source_block_id><sink_block_id>out0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>out1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_decimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>CyberRadio_vector_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
