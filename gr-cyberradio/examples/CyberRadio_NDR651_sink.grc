<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ndr651_sink_demo</value></param>
<param><key>author</key><value>CRS</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>CRS NDR651 Sink Demo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>NDR651 Sink Demo</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx1_atten</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>0, 2, 1, 1</value></param>
<param><key>label</key><value>Atten</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx1_enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>TX1: Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx1_freq</value></param>
<param><key>value</key><value>899</value></param>
<param><key>gui_hint</key><value>0, 1, 1, 1</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx2_atten</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>1, 2, 1, 1</value></param>
<param><key>label</key><value>Atten</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx2_enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>TX2: Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx2_freq</value></param>
<param><key>value</key><value>901</value></param>
<param><key>gui_hint</key><value>1, 1, 1, 1</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_atten</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2, 3, 1, 1</value></param>
<param><key>label</key><value>Atten</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_chans</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2, 4, 1, 1</value></param>
<param><key>label</key><value>Chans</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2, 2, 1, 1</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_iface</value></param>
<param><key>value</key><value>eth10</value></param>
<param><key>gui_hint</key><value>2, 0, 1, 1</value></param>
<param><key>label</key><value>DUC1: IFace</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_CyberRadio_class_method_probe</key>
<param><key>id</key><value>wbduc1_nominal_sample_rate</value></param>
<param><key>block_id</key><value>CyberRadio_NDR651_sink_0</value></param>
<param><key>function_args</key><value>1</value></param>
<param><key>function_name</key><value>get_wbduc_nominal_sample_rate</value></param>
<param><key>value</key><value>32000</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2, 1, 1, 1</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc1_stream</value></param>
<param><key>value</key><value>42001</value></param>
<param><key>gui_hint</key><value>2, 5, 1, 1</value></param>
<param><key>label</key><value>Stream</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_atten</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3, 3, 1, 1</value></param>
<param><key>label</key><value>Atten</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_chans</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>3, 4, 1, 1</value></param>
<param><key>label</key><value>Chans</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3, 2, 1, 1</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_iface</value></param>
<param><key>value</key><value>eth10</value></param>
<param><key>gui_hint</key><value>3, 0, 1, 1</value></param>
<param><key>label</key><value>DUC2: IFace</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_CyberRadio_class_method_probe</key>
<param><key>id</key><value>wbduc2_nominal_sample_rate</value></param>
<param><key>block_id</key><value>CyberRadio_NDR651_sink_0</value></param>
<param><key>function_args</key><value>2</value></param>
<param><key>function_name</key><value>get_wbduc_nominal_sample_rate</value></param>
<param><key>value</key><value>32000</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3, 1, 1, 1</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>wbduc2_stream</value></param>
<param><key>value</key><value>42002</value></param>
<param><key>gui_hint</key><value>3, 5, 1, 1</value></param>
<param><key>label</key><value>Stream</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>CyberRadio_NDR651_sink</key>
<param><key>id</key><value>CyberRadio_NDR651_sink_0</value></param>
<param><key>tengig_iface_list</key><value>['eth10', 'eth11']</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>iq_scale_factor</key><value>2**15</value></param>
<param><key>num_transmitters</key><value>2</value></param>
<param><key>num_wbducs</key><value>2</value></param>
<param><key>radio_host_name</key><value>ndr651</value></param>
<param><key>radio_host_port</key><value>8617</value></param>
<param><key>transmitter1_param_list</key><value>[tx1_enable, tx1_freq, tx1_atten]</value></param>
<param><key>transmitter2_param_list</key><value>[tx2_enable, tx2_freq, tx2_atten]</value></param>
<param><key>verbose_mode</key><value>True</value></param>
<param><key>wbduc1_param_list</key><value>[wbduc1_iface, wbduc1_rate, wbduc1_freq, wbduc1_atten, wbduc1_chans, wbduc1_stream]</value></param>
<param><key>wbduc2_param_list</key><value>[wbduc2_iface, wbduc2_rate, wbduc2_freq, wbduc2_atten, wbduc2_chans, wbduc2_stream]</value></param>
<param><key>wbduc3_param_list</key><value>["eth10", 0, 0, 0, 1, 40003]</value></param>
<param><key>wbduc4_param_list</key><value>["eth10", 0, 0, 0, 1, 40004]</value></param>
<param><key>wbduc5_param_list</key><value>["eth10", 0, 0, 0, 1, 40005]</value></param>
<param><key>wbduc6_param_list</key><value>["eth10", 0, 0, 0, 1, 40006]</value></param>
<param><key>wbduc7_param_list</key><value>["eth10", 0, 0, 0, 1, 40007]</value></param>
<param><key>wbduc8_param_list</key><value>["eth10", 0, 0, 0, 1, 40008]</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1e6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>wbduc1_nominal_sample_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1e6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>wbduc2_nominal_sample_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>blocks_file_descriptor_sink</key>
<param><key>id</key><value>blocks_file_descriptor_sink_1</value></param>
<param><key>fd</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>CyberRadio_NDR651_sink_0</source_block_id><sink_block_id>blocks_file_descriptor_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>CyberRadio_NDR651_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>CyberRadio_NDR651_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
